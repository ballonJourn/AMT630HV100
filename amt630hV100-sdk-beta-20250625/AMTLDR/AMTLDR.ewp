# IAR project AMTLDR.ewp, settings and files
configuration AMT630Hv100 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AMTLDR.bin
  postbuild: gen_checksum.exe AMT630Hv100\Exe\AMTLDR.bin
  ILINK.IlinkOutputFile: AMTLDR.out
  ILINK.IlinkIcfFile: AMTLDR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    Src/: cp15.c cp15_asm_iar.s
  group Src
    Src/: amt630h.h Boot.s BootModeSel.h clockcfg.c crc32.c crc32.h Entry.c exception.c gpio.c list.h mmu.c scsi.h sdmmc.c sdmmc.h spi.h SpiBooter.c SpinandBooter.c sysinfo.c sysinfo.h timer.c timer.h typedef.h UartPrint.c UartPrint.h wdt.c
  group Src/fs
    Src/fs/: diskio.c diskio.h ff.c ff.h integer.h sd_if.h
