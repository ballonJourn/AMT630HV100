# IAR project stepldr.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: src; Src\usb; Src\usb\include; FreeRTOS\Source\include; FreeRTOS\Source\portable
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stepldr.bin
  postbuild: gen_checksum.exe Debug\Exe\stepldr.bin
  ILINK.IlinkOutputFile: stepldr.out
  ILINK.IlinkIcfFile: stepldr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: asm.out
  group (top)
    Src/: amt630h.h uart.h
  group FreeRTOS
    FreeRTOS/Source/: list.c
  group FreeRTOS/portable/MemMang
    FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Src
    Src/: aic.c board.h Boot.s cp15.c cp15_asm_iar.s crc32.c crc32.h Entry.c exception.c gpio.c i2c-gpio.c i2c.c lcd.c list.h mipi.c mmu.c os_adapt.c pinctrl.c pxp.c pxp.h sdmmc.c sdmmc.h spi.h SpiBooter.c SpinandBooter.c sysctl.c sysinfo.c timer.c timer.h typedef.h uart.c update.c wdt.c
  group Src/fs
    Src/fs/: diskio.c diskio.h ff.c ff.h integer.h sd_if.h
  group Src/usb
    Src/usb/: ark_dwc2.c core.c core_intr.c hcd.c hcd_intr.c hcd_queue.c params.c platform.c usb.c usb_massstorage.c usb_os_adapter.c
