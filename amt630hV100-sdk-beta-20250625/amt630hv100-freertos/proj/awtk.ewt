<?xml version="1.0" encoding="UTF-8"?>
<project>
    <fileVersion>3</fileVersion>
    <configuration>
        <name>library</name>
        <toolchain>
            <name>ARM</name>
        </toolchain>
        <debug>1</debug>
        <settings>
            <name>C-STAT</name>
            <archiveVersion>261</archiveVersion>
            <data>
                <version>261</version>
                <cstatargs>
                    <useExtraArgs>0</useExtraArgs>
                    <extraArgs></extraArgs>
                    <analyzeTimeoutEnabled>1</analyzeTimeoutEnabled>
                    <analyzeTimeout>600</analyzeTimeout>
                    <enableParallel>1</enableParallel>
                    <parallelThreads>8</parallelThreads>
                    <enableFalsePositives>0</enableFalsePositives>
                    <messagesLimitEnabled>1</messagesLimitEnabled>
                    <messagesLimit>100</messagesLimit>
                </cstatargs>
                <cstat_settings>
                    <cstat_version>1.5.3</cstat_version>
                    <checks_tree>
                        <package name="STDCHECKS" enabled="true">
                            <group enabled="true" name="ARR">
                                <check name="ARR-inv-index-pos" enabled="true" />
                                <check name="ARR-inv-index-ptr-pos" enabled="true" />
                                <check name="ARR-inv-index-ptr" enabled="true" />
                                <check name="ARR-inv-index" enabled="true" />
                                <check name="ARR-neg-index" enabled="true" />
                                <check name="ARR-uninit-index" enabled="true" />
                            </group>
                            <group enabled="true" name="ATH">
                                <check name="ATH-cmp-float" enabled="true" />
                                <check name="ATH-cmp-unsign-neg" enabled="true" />
                                <check name="ATH-cmp-unsign-pos" enabled="true" />
                                <check name="ATH-div-0-assign" enabled="true" />
                                <check name="ATH-div-0-cmp-aft" enabled="false" />
                                <check name="ATH-div-0-cmp-bef" enabled="true" />
                                <check name="ATH-div-0-interval" enabled="true" />
                                <check name="ATH-div-0-pos" enabled="true" />
                                <check name="ATH-div-0-unchk-global" enabled="true" />
                                <check name="ATH-div-0-unchk-local" enabled="true" />
                                <check name="ATH-div-0-unchk-param" enabled="true" />
                                <check name="ATH-div-0" enabled="true" />
                                <check name="ATH-inc-bool" enabled="true" />
                                <check name="ATH-malloc-overrun" enabled="true" />
                                <check name="ATH-neg-check-nonneg" enabled="true" />
                                <check name="ATH-neg-check-pos" enabled="true" />
                                <check name="ATH-new-overrun" enabled="true" />
                                <check name="ATH-overflow-cast" enabled="false" />
                                <check name="ATH-overflow" enabled="true" />
                                <check name="ATH-shift-bounds" enabled="true" />
                                <check name="ATH-shift-neg" enabled="true" />
                                <check name="ATH-sizeof-by-sizeof" enabled="true" />
                            </group>
                            <group enabled="true" name="CAST">
                                <check name="CAST-old-style" enabled="false" />
                            </group>
                            <group enabled="true" name="CATCH">
                                <check name="CATCH-object-slicing" enabled="true" />
                                <check name="CATCH-xtor-bad-member" enabled="false" />
                            </group>
                            <group enabled="true" name="COMMA">
                                <check name="COMMA-overload" enabled="false" />
                            </group>
                            <group enabled="true" name="COMMENT">
                                <check name="COMMENT-nested" enabled="true" />
                            </group>
                            <group enabled="true" name="CONST">
                                <check name="CONST-member-ret" enabled="true" />
                            </group>
                            <group enabled="true" name="COP">
                                <check name="COP-alloc-ctor" enabled="false" />
                                <check name="COP-assign-op-ret" enabled="true" />
                                <check name="COP-assign-op-self" enabled="true" />
                                <check name="COP-assign-op" enabled="true" />
                                <check name="COP-copy-ctor" enabled="true" />
                                <check name="COP-dealloc-dtor" enabled="false" />
                                <check name="COP-dtor-throw" enabled="true" />
                                <check name="COP-dtor" enabled="true" />
                                <check name="COP-init-order" enabled="true" />
                                <check name="COP-init-uninit" enabled="true" />
                                <check name="COP-member-uninit" enabled="true" />
                            </group>
                            <group enabled="true" name="CPU">
                                <check name="CPU-ctor-call-virt" enabled="true" />
                                <check name="CPU-ctor-implicit" enabled="false" />
                                <check name="CPU-delete-throw" enabled="true" />
                                <check name="CPU-delete-void" enabled="true" />
                                <check name="CPU-dtor-call-virt" enabled="true" />
                                <check name="CPU-malloc-class" enabled="true" />
                                <check name="CPU-nonvirt-dtor" enabled="true" />
                                <check name="CPU-return-ref-to-class-data" enabled="true" />
                            </group>
                            <group enabled="true" name="DECL">
                                <check name="DECL-implicit-int" enabled="false" />
                            </group>
                            <group enabled="true" name="DEFINE">
                                <check name="DEFINE-hash-multiple" enabled="true" />
                            </group>
                            <group enabled="true" name="ENUM">
                                <check name="ENUM-bounds" enabled="false" />
                            </group>
                            <group enabled="true" name="EXP">
                                <check name="EXP-cond-assign" enabled="true" />
                                <check name="EXP-dangling-else" enabled="true" />
                                <check name="EXP-loop-exit" enabled="true" />
                                <check name="EXP-main-ret-int" enabled="false" />
                                <check name="EXP-null-stmt" enabled="false" />
                                <check name="EXP-stray-semicolon" enabled="false" />
                            </group>
                            <group enabled="true" name="EXPR">
                                <check name="EXPR-const-overflow" enabled="true" />
                            </group>
                            <group enabled="true" name="FPT">
                                <check name="FPT-cmp-null" enabled="true" />
                                <check name="FPT-literal" enabled="false" />
                                <check name="FPT-misuse" enabled="true" />
                            </group>
                            <group enabled="true" name="FUNC">
                                <check name="FUNC-implicit-decl" enabled="false" />
                                <check name="FUNC-unprototyped-all" enabled="false" />
                                <check name="FUNC-unprototyped-used" enabled="true" />
                            </group>
                            <group enabled="true" name="INCLUDE">
                                <check name="INCLUDE-c-file" enabled="false" />
                            </group>
                            <group enabled="true" name="INT">
                                <check name="INT-use-signed-as-unsigned-pos" enabled="false" />
                                <check name="INT-use-signed-as-unsigned" enabled="true" />
                            </group>
                            <group enabled="true" name="ITR">
                                <check name="ITR-end-cmp-aft" enabled="true" />
                                <check name="ITR-end-cmp-bef" enabled="true" />
                                <check name="ITR-invalidated" enabled="true" />
                                <check name="ITR-mismatch-alg" enabled="false" />
                                <check name="ITR-store" enabled="false" />
                                <check name="ITR-uninit" enabled="true" />
                            </group>
                            <group enabled="true" name="LIB">
                                <check name="LIB-bsearch-overrun-pos" enabled="false" />
                                <check name="LIB-bsearch-overrun" enabled="false" />
                                <check name="LIB-fn-unsafe" enabled="false" />
                                <check name="LIB-fread-overrun-pos" enabled="false" />
                                <check name="LIB-fread-overrun" enabled="true" />
                                <check name="LIB-memchr-overrun-pos" enabled="false" />
                                <check name="LIB-memchr-overrun" enabled="true" />
                                <check name="LIB-memcpy-overrun-pos" enabled="false" />
                                <check name="LIB-memcpy-overrun" enabled="true" />
                                <check name="LIB-memset-overrun-pos" enabled="false" />
                                <check name="LIB-memset-overrun" enabled="true" />
                                <check name="LIB-putenv" enabled="false" />
                                <check name="LIB-qsort-overrun-pos" enabled="false" />
                                <check name="LIB-qsort-overrun" enabled="false" />
                                <check name="LIB-return-const" enabled="true" />
                                <check name="LIB-return-error" enabled="true" />
                                <check name="LIB-return-leak" enabled="true" />
                                <check name="LIB-return-neg" enabled="true" />
                                <check name="LIB-return-null" enabled="true" />
                                <check name="LIB-sprintf-overrun" enabled="false" />
                                <check name="LIB-std-sort-overrun-pos" enabled="false" />
                                <check name="LIB-std-sort-overrun" enabled="true" />
                                <check name="LIB-strcat-overrun-pos" enabled="false" />
                                <check name="LIB-strcat-overrun" enabled="true" />
                                <check name="LIB-strcpy-overrun-pos" enabled="false" />
                                <check name="LIB-strcpy-overrun" enabled="true" />
                                <check name="LIB-strncat-overrun-pos" enabled="false" />
                                <check name="LIB-strncat-overrun" enabled="true" />
                                <check name="LIB-strncmp-overrun-pos" enabled="false" />
                                <check name="LIB-strncmp-overrun" enabled="true" />
                                <check name="LIB-strncpy-overrun-pos" enabled="false" />
                                <check name="LIB-strncpy-overrun" enabled="true" />
                            </group>
                            <group enabled="true" name="LOGIC">
                                <check name="LOGIC-overload" enabled="false" />
                            </group>
                            <group enabled="true" name="MEM">
                                <check name="MEM-delete-array-op" enabled="true" />
                                <check name="MEM-delete-op" enabled="true" />
                                <check name="MEM-double-free-alias" enabled="true" />
                                <check name="MEM-double-free-some" enabled="true" />
                                <check name="MEM-double-free" enabled="true" />
                                <check name="MEM-free-field" enabled="true" />
                                <check name="MEM-free-fptr" enabled="true" />
                                <check name="MEM-free-no-alloc-struct" enabled="false" />
                                <check name="MEM-free-no-alloc" enabled="false" />
                                <check name="MEM-free-no-use" enabled="true" />
                                <check name="MEM-free-op" enabled="true" />
                                <check name="MEM-free-struct-field" enabled="true" />
                                <check name="MEM-free-variable-alias" enabled="true" />
                                <check name="MEM-free-variable" enabled="true" />
                                <check name="MEM-leak-alias" enabled="true" />
                                <check name="MEM-leak" enabled="false" />
                                <check name="MEM-malloc-arith" enabled="false" />
                                <check name="MEM-malloc-diff-type" enabled="true" />
                                <check name="MEM-malloc-sizeof-ptr" enabled="true" />
                                <check name="MEM-malloc-sizeof" enabled="true" />
                                <check name="MEM-malloc-strlen" enabled="false" />
                                <check name="MEM-realloc-diff-type" enabled="true" />
                                <check name="MEM-return-free" enabled="true" />
                                <check name="MEM-return-no-assign" enabled="true" />
                                <check name="MEM-stack-global-field" enabled="true" />
                                <check name="MEM-stack-global" enabled="true" />
                                <check name="MEM-stack-param-ref" enabled="true" />
                                <check name="MEM-stack-param" enabled="true" />
                                <check name="MEM-stack-pos" enabled="true" />
                                <check name="MEM-stack-ref" enabled="true" />
                                <check name="MEM-stack" enabled="true" />
                                <check name="MEM-use-free-all" enabled="true" />
                                <check name="MEM-use-free-some" enabled="true" />
                            </group>
                            <group enabled="true" name="PTR">
                                <check name="PTR-arith-field" enabled="true" />
                                <check name="PTR-arith-stack" enabled="true" />
                                <check name="PTR-arith-var" enabled="true" />
                                <check name="PTR-cmp-str-lit" enabled="true" />
                                <check name="PTR-null-assign-fun-pos" enabled="false" />
                                <check name="PTR-null-assign-pos" enabled="false" />
                                <check name="PTR-null-assign" enabled="true" />
                                <check name="PTR-null-cmp-aft" enabled="true" />
                                <check name="PTR-null-cmp-bef-fun" enabled="true" />
                                <check name="PTR-null-cmp-bef" enabled="true" />
                                <check name="PTR-null-fun-pos" enabled="true" />
                                <check name="PTR-null-literal-pos" enabled="false" />
                                <check name="PTR-overload" enabled="false" />
                                <check name="PTR-singleton-arith-pos" enabled="false" />
                                <check name="PTR-singleton-arith" enabled="true" />
                                <check name="PTR-unchk-param-some" enabled="true" />
                                <check name="PTR-unchk-param" enabled="false" />
                                <check name="PTR-uninit-pos" enabled="false" />
                                <check name="PTR-uninit" enabled="true" />
                            </group>
                            <group enabled="true" name="RED">
                                <check name="RED-alloc-zero-bytes" enabled="false" />
                                <check name="RED-case-reach" enabled="false" />
                                <check name="RED-cmp-always" enabled="false" />
                                <check name="RED-cmp-never" enabled="false" />
                                <check name="RED-cond-always" enabled="false" />
                                <check name="RED-cond-const-assign" enabled="true" />
                                <check name="RED-cond-const-expr" enabled="false" />
                                <check name="RED-cond-const" enabled="false" />
                                <check name="RED-cond-never" enabled="false" />
                                <check name="RED-dead" enabled="true" />
                                <check name="RED-expr" enabled="false" />
                                <check name="RED-func-no-effect" enabled="false" />
                                <check name="RED-local-hides-global" enabled="true" />
                                <check name="RED-local-hides-local" enabled="false" />
                                <check name="RED-local-hides-member" enabled="false" />
                                <check name="RED-local-hides-param" enabled="true" />
                                <check name="RED-no-effect" enabled="false" />
                                <check name="RED-self-assign" enabled="true" />
                                <check name="RED-unused-assign" enabled="true" />
                                <check name="RED-unused-param" enabled="false" />
                                <check name="RED-unused-return-val" enabled="false" />
                                <check name="RED-unused-val" enabled="false" />
                                <check name="RED-unused-var-all" enabled="true" />
                            </group>
                            <group enabled="true" name="RESOURCE">
                                <check name="RESOURCE-deref-file" enabled="false" />
                                <check name="RESOURCE-double-close" enabled="true" />
                                <check name="RESOURCE-file-no-close-all" enabled="true" />
                                <check name="RESOURCE-file-pos-neg" enabled="false" />
                                <check name="RESOURCE-file-use-after-close" enabled="true" />
                                <check name="RESOURCE-implicit-deref-file" enabled="false" />
                                <check name="RESOURCE-write-ronly-file" enabled="true" />
                            </group>
                            <group enabled="true" name="SIZEOF">
                                <check name="SIZEOF-side-effect" enabled="true" />
                            </group>
                            <group enabled="true" name="SPC">
                                <check name="SPC-order" enabled="true" />
                                <check name="SPC-uninit-arr-all" enabled="false" />
                                <check name="SPC-uninit-struct-field-heap" enabled="true" />
                                <check name="SPC-uninit-struct-field" enabled="false" />
                                <check name="SPC-uninit-struct" enabled="true" />
                                <check name="SPC-uninit-var-all" enabled="true" />
                                <check name="SPC-uninit-var-some" enabled="true" />
                                <check name="SPC-volatile-reads" enabled="false" />
                                <check name="SPC-volatile-writes" enabled="false" />
                            </group>
                            <group enabled="true" name="STRUCT">
                                <check name="STRUCT-signed-bit" enabled="false" />
                            </group>
                            <group enabled="true" name="SWITCH">
                                <check name="SWITCH-fall-through" enabled="true" />
                            </group>
                            <group enabled="true" name="THROW">
                                <check name="THROW-empty" enabled="false" />
                                <check name="THROW-main" enabled="false" />
                                <check name="THROW-null" enabled="true" />
                                <check name="THROW-ptr" enabled="true" />
                                <check name="THROW-static" enabled="true" />
                                <check name="THROW-unhandled" enabled="true" />
                            </group>
                            <group enabled="true" name="UNION">
                                <check name="UNION-overlap-assign" enabled="true" />
                                <check name="UNION-type-punning" enabled="true" />
                            </group>
                        </package>
                        <package name="CERT" enabled="false">
                            <group enabled="true" name="CERT-EXP">
                                <check name="CERT-EXP19-C" enabled="true" />
                            </group>
                            <group enabled="true" name="CERT-FIO">
                                <check name="CERT-FIO37-C" enabled="true" />
                                <check name="CERT-FIO38-C" enabled="true" />
                            </group>
                            <group enabled="true" name="CERT-SIG">
                                <check name="CERT-SIG31-C" enabled="true" />
                            </group>
                        </package>
                        <package name="SECURITY" enabled="false">
                            <group enabled="true" name="SEC-BUFFER">
                                <check name="SEC-BUFFER-memory-leak-alias" enabled="true" />
                                <check name="SEC-BUFFER-memory-leak" enabled="false" />
                                <check name="SEC-BUFFER-memset-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-memset-overrun" enabled="true" />
                                <check name="SEC-BUFFER-qsort-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-qsort-overrun" enabled="true" />
                                <check name="SEC-BUFFER-sprintf-overrun" enabled="true" />
                                <check name="SEC-BUFFER-std-sort-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-std-sort-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strcat-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strcat-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strcpy-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strcpy-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strncat-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strncat-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strncmp-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strncmp-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strncpy-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strncpy-overrun" enabled="true" />
                                <check name="SEC-BUFFER-tainted-alloc-size" enabled="true" />
                                <check name="SEC-BUFFER-tainted-copy-length" enabled="true" />
                                <check name="SEC-BUFFER-tainted-copy" enabled="true" />
                                <check name="SEC-BUFFER-tainted-index" enabled="true" />
                                <check name="SEC-BUFFER-tainted-offset" enabled="true" />
                                <check name="SEC-BUFFER-use-after-free-all" enabled="true" />
                                <check name="SEC-BUFFER-use-after-free-some" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-DIV-0">
                                <check name="SEC-DIV-0-compare-after" enabled="true" />
                                <check name="SEC-DIV-0-compare-before" enabled="true" />
                                <check name="SEC-DIV-0-tainted" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-FILEOP">
                                <check name="SEC-FILEOP-open-no-close" enabled="true" />
                                <check name="SEC-FILEOP-path-traversal" enabled="false" />
                                <check name="SEC-FILEOP-use-after-close" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-INJECTION">
                                <check name="SEC-INJECTION-sql" enabled="false" />
                                <check name="SEC-INJECTION-xpath" enabled="false" />
                            </group>
                            <group enabled="true" name="SEC-LOOP">
                                <check name="SEC-LOOP-tainted-bound" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-NULL">
                                <check name="SEC-NULL-assignment-fun-pos" enabled="false" />
                                <check name="SEC-NULL-assignment" enabled="true" />
                                <check name="SEC-NULL-cmp-aft" enabled="true" />
                                <check name="SEC-NULL-cmp-bef-fun" enabled="true" />
                                <check name="SEC-NULL-cmp-bef" enabled="true" />
                                <check name="SEC-NULL-literal-pos" enabled="false" />
                            </group>
                            <group enabled="true" name="SEC-STRING">
                                <check name="SEC-STRING-format-string" enabled="true" />
                                <check name="SEC-STRING-hard-coded-credentials" enabled="false" />
                            </group>
                        </package>
                        <package name="MISRAC2004" enabled="false">
                            <group enabled="true" name="MISRAC2004-1">
                                <check name="MISRAC2004-1.1" enabled="true" />
                                <check name="MISRAC2004-1.2_a" enabled="true" />
                                <check name="MISRAC2004-1.2_b" enabled="true" />
                                <check name="MISRAC2004-1.2_c" enabled="true" />
                                <check name="MISRAC2004-1.2_d" enabled="true" />
                                <check name="MISRAC2004-1.2_e" enabled="true" />
                                <check name="MISRAC2004-1.2_f" enabled="true" />
                                <check name="MISRAC2004-1.2_g" enabled="true" />
                                <check name="MISRAC2004-1.2_h" enabled="true" />
                                <check name="MISRAC2004-1.2_i" enabled="true" />
                                <check name="MISRAC2004-1.2_j" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-2">
                                <check name="MISRAC2004-2.1" enabled="true" />
                                <check name="MISRAC2004-2.2" enabled="true" />
                                <check name="MISRAC2004-2.3" enabled="true" />
                                <check name="MISRAC2004-2.4" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2004-5">
                                <check name="MISRAC2004-5.2" enabled="true" />
                                <check name="MISRAC2004-5.3" enabled="true" />
                                <check name="MISRAC2004-5.4" enabled="true" />
                                <check name="MISRAC2004-5.5" enabled="false" />
                                <check name="MISRAC2004-5.6" enabled="false" />
                                <check name="MISRAC2004-5.7" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2004-6">
                                <check name="MISRAC2004-6.1" enabled="true" />
                                <check name="MISRAC2004-6.2" enabled="true" />
                                <check name="MISRAC2004-6.3" enabled="false" />
                                <check name="MISRAC2004-6.4" enabled="true" />
                                <check name="MISRAC2004-6.5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-7">
                                <check name="MISRAC2004-7.1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-8">
                                <check name="MISRAC2004-8.1" enabled="true" />
                                <check name="MISRAC2004-8.2" enabled="true" />
                                <check name="MISRAC2004-8.3" enabled="true" />
                                <check name="MISRAC2004-8.5_a" enabled="true" />
                                <check name="MISRAC2004-8.5_b" enabled="true" />
                                <check name="MISRAC2004-8.6" enabled="true" />
                                <check name="MISRAC2004-8.7" enabled="true" />
                                <check name="MISRAC2004-8.8_a" enabled="true" />
                                <check name="MISRAC2004-8.8_b" enabled="true" />
                                <check name="MISRAC2004-8.12" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-8 10">
                                <check name="MISRAC2004-8.10" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-9">
                                <check name="MISRAC2004-9.1_a" enabled="true" />
                                <check name="MISRAC2004-9.1_b" enabled="true" />
                                <check name="MISRAC2004-9.1_c" enabled="true" />
                                <check name="MISRAC2004-9.2" enabled="true" />
                                <check name="MISRAC2004-9.3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-10">
                                <check name="MISRAC2004-10.1_a" enabled="true" />
                                <check name="MISRAC2004-10.1_b" enabled="true" />
                                <check name="MISRAC2004-10.1_c" enabled="true" />
                                <check name="MISRAC2004-10.1_d" enabled="true" />
                                <check name="MISRAC2004-10.2_a" enabled="true" />
                                <check name="MISRAC2004-10.2_b" enabled="true" />
                                <check name="MISRAC2004-10.2_c" enabled="true" />
                                <check name="MISRAC2004-10.2_d" enabled="true" />
                                <check name="MISRAC2004-10.3" enabled="true" />
                                <check name="MISRAC2004-10.4" enabled="true" />
                                <check name="MISRAC2004-10.5" enabled="true" />
                                <check name="MISRAC2004-10.6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-11">
                                <check name="MISRAC2004-11.1" enabled="true" />
                                <check name="MISRAC2004-11.3" enabled="false" />
                                <check name="MISRAC2004-11.4" enabled="false" />
                                <check name="MISRAC2004-11.5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-12">
                                <check name="MISRAC2004-12.1" enabled="false" />
                                <check name="MISRAC2004-12.2_a" enabled="true" />
                                <check name="MISRAC2004-12.2_b" enabled="true" />
                                <check name="MISRAC2004-12.2_c" enabled="true" />
                                <check name="MISRAC2004-12.3" enabled="true" />
                                <check name="MISRAC2004-12.4" enabled="true" />
                                <check name="MISRAC2004-12.5" enabled="true" />
                                <check name="MISRAC2004-12.6_a" enabled="false" />
                                <check name="MISRAC2004-12.6_b" enabled="false" />
                                <check name="MISRAC2004-12.7" enabled="true" />
                                <check name="MISRAC2004-12.8" enabled="true" />
                                <check name="MISRAC2004-12.9" enabled="true" />
                                <check name="MISRAC2004-12.10" enabled="true" />
                                <check name="MISRAC2004-12.11" enabled="false" />
                                <check name="MISRAC2004-12.12_a" enabled="true" />
                                <check name="MISRAC2004-12.12_b" enabled="true" />
                                <check name="MISRAC2004-12.13" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2004-13">
                                <check name="MISRAC2004-13.1" enabled="true" />
                                <check name="MISRAC2004-13.2_a" enabled="false" />
                                <check name="MISRAC2004-13.2_b" enabled="false" />
                                <check name="MISRAC2004-13.2_c" enabled="false" />
                                <check name="MISRAC2004-13.2_d" enabled="false" />
                                <check name="MISRAC2004-13.2_e" enabled="false" />
                                <check name="MISRAC2004-13.3" enabled="true" />
                                <check name="MISRAC2004-13.4" enabled="true" />
                                <check name="MISRAC2004-13.5" enabled="true" />
                                <check name="MISRAC2004-13.6" enabled="true" />
                                <check name="MISRAC2004-13.7_a" enabled="true" />
                                <check name="MISRAC2004-13.7_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-14">
                                <check name="MISRAC2004-14.1" enabled="true" />
                                <check name="MISRAC2004-14.2" enabled="true" />
                                <check name="MISRAC2004-14.3" enabled="true" />
                                <check name="MISRAC2004-14.4" enabled="true" />
                                <check name="MISRAC2004-14.5" enabled="true" />
                                <check name="MISRAC2004-14.6" enabled="true" />
                                <check name="MISRAC2004-14.7" enabled="true" />
                                <check name="MISRAC2004-14.8_a" enabled="true" />
                                <check name="MISRAC2004-14.8_b" enabled="true" />
                                <check name="MISRAC2004-14.8_c" enabled="true" />
                                <check name="MISRAC2004-14.8_d" enabled="true" />
                                <check name="MISRAC2004-14.9" enabled="true" />
                                <check name="MISRAC2004-14.10" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-15">
                                <check name="MISRAC2004-15.0" enabled="true" />
                                <check name="MISRAC2004-15.1" enabled="true" />
                                <check name="MISRAC2004-15.2" enabled="true" />
                                <check name="MISRAC2004-15.3" enabled="true" />
                                <check name="MISRAC2004-15.4" enabled="true" />
                                <check name="MISRAC2004-15.5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-16">
                                <check name="MISRAC2004-16.1" enabled="true" />
                                <check name="MISRAC2004-16.2_a" enabled="true" />
                                <check name="MISRAC2004-16.2_b" enabled="true" />
                                <check name="MISRAC2004-16.3" enabled="true" />
                                <check name="MISRAC2004-16.4" enabled="true" />
                                <check name="MISRAC2004-16.5" enabled="true" />
                                <check name="MISRAC2004-16.7" enabled="true" />
                                <check name="MISRAC2004-16.8" enabled="true" />
                                <check name="MISRAC2004-16.9" enabled="true" />
                                <check name="MISRAC2004-16.10" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-17">
                                <check name="MISRAC2004-17.1_a" enabled="true" />
                                <check name="MISRAC2004-17.1_b" enabled="true" />
                                <check name="MISRAC2004-17.1_c" enabled="true" />
                                <check name="MISRAC2004-17.2" enabled="true" />
                                <check name="MISRAC2004-17.3" enabled="true" />
                                <check name="MISRAC2004-17.4_a" enabled="true" />
                                <check name="MISRAC2004-17.4_b" enabled="true" />
                                <check name="MISRAC2004-17.5" enabled="true" />
                                <check name="MISRAC2004-17.6_a" enabled="true" />
                                <check name="MISRAC2004-17.6_b" enabled="true" />
                                <check name="MISRAC2004-17.6_c" enabled="true" />
                                <check name="MISRAC2004-17.6_d" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-18">
                                <check name="MISRAC2004-18.1" enabled="true" />
                                <check name="MISRAC2004-18.2" enabled="true" />
                                <check name="MISRAC2004-18.4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-19">
                                <check name="MISRAC2004-19.1" enabled="false" />
                                <check name="MISRAC2004-19.2" enabled="false" />
                                <check name="MISRAC2004-19.4" enabled="true" />
                                <check name="MISRAC2004-19.5" enabled="true" />
                                <check name="MISRAC2004-19.6" enabled="true" />
                                <check name="MISRAC2004-19.7" enabled="false" />
                                <check name="MISRAC2004-19.10" enabled="true" />
                                <check name="MISRAC2004-19.12" enabled="true" />
                                <check name="MISRAC2004-19.13" enabled="false" />
                                <check name="MISRAC2004-19.15" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-20">
                                <check name="MISRAC2004-20.1" enabled="true" />
                                <check name="MISRAC2004-20.2" enabled="true" />
                                <check name="MISRAC2004-20.3_a" enabled="true" />
                                <check name="MISRAC2004-20.3_b" enabled="true" />
                                <check name="MISRAC2004-20.3_c" enabled="true" />
                                <check name="MISRAC2004-20.3_d" enabled="true" />
                                <check name="MISRAC2004-20.3_e" enabled="true" />
                                <check name="MISRAC2004-20.3_f" enabled="true" />
                                <check name="MISRAC2004-20.3_g" enabled="true" />
                                <check name="MISRAC2004-20.3_h" enabled="true" />
                                <check name="MISRAC2004-20.3_i" enabled="true" />
                                <check name="MISRAC2004-20.4" enabled="true" />
                                <check name="MISRAC2004-20.5" enabled="true" />
                                <check name="MISRAC2004-20.6" enabled="true" />
                                <check name="MISRAC2004-20.7" enabled="true" />
                                <check name="MISRAC2004-20.8" enabled="true" />
                                <check name="MISRAC2004-20.9" enabled="true" />
                                <check name="MISRAC2004-20.10" enabled="true" />
                                <check name="MISRAC2004-20.11" enabled="true" />
                                <check name="MISRAC2004-20.12" enabled="true" />
                            </group>
                        </package>
                        <package name="MISRAC2012" enabled="false">
                            <group enabled="true" name="MISRAC2012-Dir-4">
                                <check name="MISRAC2012-Dir-4.3" enabled="true" />
                                <check name="MISRAC2012-Dir-4.4" enabled="false" />
                                <check name="MISRAC2012-Dir-4.5" enabled="false" />
                                <check name="MISRAC2012-Dir-4.6_a" enabled="false" />
                                <check name="MISRAC2012-Dir-4.6_b" enabled="false" />
                                <check name="MISRAC2012-Dir-4.7_a" enabled="false" />
                                <check name="MISRAC2012-Dir-4.7_b" enabled="false" />
                                <check name="MISRAC2012-Dir-4.7_c" enabled="false" />
                                <check name="MISRAC2012-Dir-4.8" enabled="false" />
                                <check name="MISRAC2012-Dir-4.9" enabled="false" />
                                <check name="MISRAC2012-Dir-4.10" enabled="true" />
                                <check name="MISRAC2012-Dir-4.11_a" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_b" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_c" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_d" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_e" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_f" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_g" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_h" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_i" enabled="false" />
                                <check name="MISRAC2012-Dir-4.12" enabled="false" />
                                <check name="MISRAC2012-Dir-4.13_b" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_c" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_d" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_e" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_f" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_g" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_h" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-1">
                                <check name="MISRAC2012-Rule-1.3_a" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_b" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_c" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_d" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_e" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_f" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_g" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_h" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_i" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_j" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_k" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_m" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_n" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_o" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_p" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_q" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_r" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_s" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_t" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_u" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_v" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_w" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-2">
                                <check name="MISRAC2012-Rule-2.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-2.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-2.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-2.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-2.2_c" enabled="true" />
                                <check name="MISRAC2012-Rule-2.3" enabled="false" />
                                <check name="MISRAC2012-Rule-2.4" enabled="false" />
                                <check name="MISRAC2012-Rule-2.5" enabled="false" />
                                <check name="MISRAC2012-Rule-2.6" enabled="false" />
                                <check name="MISRAC2012-Rule-2.7" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-3">
                                <check name="MISRAC2012-Rule-3.1" enabled="true" />
                                <check name="MISRAC2012-Rule-3.2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-5">
                                <check name="MISRAC2012-Rule-5.1" enabled="true" />
                                <check name="MISRAC2012-Rule-5.2_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.2_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.3_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.3_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.4_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.4_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.5_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.5_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.6" enabled="true" />
                                <check name="MISRAC2012-Rule-5.7" enabled="true" />
                                <check name="MISRAC2012-Rule-5.8" enabled="true" />
                                <check name="MISRAC2012-Rule-5.9" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-6">
                                <check name="MISRAC2012-Rule-6.1" enabled="true" />
                                <check name="MISRAC2012-Rule-6.2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-7">
                                <check name="MISRAC2012-Rule-7.1" enabled="true" />
                                <check name="MISRAC2012-Rule-7.2" enabled="true" />
                                <check name="MISRAC2012-Rule-7.3" enabled="true" />
                                <check name="MISRAC2012-Rule-7.4_a" enabled="true" />
                                <check name="MISRAC2012-Rule-7.4_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-8">
                                <check name="MISRAC2012-Rule-8.1" enabled="true" />
                                <check name="MISRAC2012-Rule-8.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-8.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-8.3_b" enabled="true" />
                                <check name="MISRAC2012-Rule-8.4" enabled="true" />
                                <check name="MISRAC2012-Rule-8.5_a" enabled="true" />
                                <check name="MISRAC2012-Rule-8.5_b" enabled="true" />
                                <check name="MISRAC2012-Rule-8.7" enabled="false" />
                                <check name="MISRAC2012-Rule-8.9_a" enabled="false" />
                                <check name="MISRAC2012-Rule-8.9_b" enabled="false" />
                                <check name="MISRAC2012-Rule-8.10" enabled="true" />
                                <check name="MISRAC2012-Rule-8.11" enabled="false" />
                                <check name="MISRAC2012-Rule-8.12" enabled="true" />
                                <check name="MISRAC2012-Rule-8.13" enabled="false" />
                                <check name="MISRAC2012-Rule-8.14" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-9">
                                <check name="MISRAC2012-Rule-9.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_c" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_d" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_e" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_f" enabled="true" />
                                <check name="MISRAC2012-Rule-9.2" enabled="true" />
                                <check name="MISRAC2012-Rule-9.3" enabled="true" />
                                <check name="MISRAC2012-Rule-9.4" enabled="true" />
                                <check name="MISRAC2012-Rule-9.5_a" enabled="true" />
                                <check name="MISRAC2012-Rule-9.5_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-10">
                                <check name="MISRAC2012-Rule-10.1_R2" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R3" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R4" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R5" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R6" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R7" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R8" enabled="true" />
                                <check name="MISRAC2012-Rule-10.2" enabled="true" />
                                <check name="MISRAC2012-Rule-10.3" enabled="true" />
                                <check name="MISRAC2012-Rule-10.4_a" enabled="true" />
                                <check name="MISRAC2012-Rule-10.4_b" enabled="true" />
                                <check name="MISRAC2012-Rule-10.5" enabled="false" />
                                <check name="MISRAC2012-Rule-10.6" enabled="true" />
                                <check name="MISRAC2012-Rule-10.7" enabled="true" />
                                <check name="MISRAC2012-Rule-10.8" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-11">
                                <check name="MISRAC2012-Rule-11.1" enabled="true" />
                                <check name="MISRAC2012-Rule-11.2" enabled="true" />
                                <check name="MISRAC2012-Rule-11.3" enabled="true" />
                                <check name="MISRAC2012-Rule-11.4" enabled="false" />
                                <check name="MISRAC2012-Rule-11.5" enabled="false" />
                                <check name="MISRAC2012-Rule-11.6" enabled="true" />
                                <check name="MISRAC2012-Rule-11.7" enabled="true" />
                                <check name="MISRAC2012-Rule-11.8" enabled="true" />
                                <check name="MISRAC2012-Rule-11.9" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-12">
                                <check name="MISRAC2012-Rule-12.1" enabled="false" />
                                <check name="MISRAC2012-Rule-12.2" enabled="true" />
                                <check name="MISRAC2012-Rule-12.3" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-13">
                                <check name="MISRAC2012-Rule-13.1" enabled="true" />
                                <check name="MISRAC2012-Rule-13.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-13.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-13.2_c" enabled="true" />
                                <check name="MISRAC2012-Rule-13.3" enabled="false" />
                                <check name="MISRAC2012-Rule-13.4_a" enabled="false" />
                                <check name="MISRAC2012-Rule-13.4_b" enabled="false" />
                                <check name="MISRAC2012-Rule-13.5" enabled="true" />
                                <check name="MISRAC2012-Rule-13.6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-14">
                                <check name="MISRAC2012-Rule-14.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-14.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-14.2" enabled="true" />
                                <check name="MISRAC2012-Rule-14.3_a" enabled="true" />
                                <check name="MISRAC2012-Rule-14.3_b" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_a" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_b" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_c" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_d" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-15">
                                <check name="MISRAC2012-Rule-15.1" enabled="false" />
                                <check name="MISRAC2012-Rule-15.2" enabled="true" />
                                <check name="MISRAC2012-Rule-15.3" enabled="true" />
                                <check name="MISRAC2012-Rule-15.4" enabled="false" />
                                <check name="MISRAC2012-Rule-15.5" enabled="false" />
                                <check name="MISRAC2012-Rule-15.6_a" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_b" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_c" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_d" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_e" enabled="true" />
                                <check name="MISRAC2012-Rule-15.7" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-16">
                                <check name="MISRAC2012-Rule-16.1" enabled="true" />
                                <check name="MISRAC2012-Rule-16.2" enabled="true" />
                                <check name="MISRAC2012-Rule-16.3" enabled="true" />
                                <check name="MISRAC2012-Rule-16.4" enabled="true" />
                                <check name="MISRAC2012-Rule-16.5" enabled="true" />
                                <check name="MISRAC2012-Rule-16.6" enabled="true" />
                                <check name="MISRAC2012-Rule-16.7" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-17">
                                <check name="MISRAC2012-Rule-17.1" enabled="true" />
                                <check name="MISRAC2012-Rule-17.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-17.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-17.3" enabled="true" />
                                <check name="MISRAC2012-Rule-17.4" enabled="true" />
                                <check name="MISRAC2012-Rule-17.5" enabled="false" />
                                <check name="MISRAC2012-Rule-17.6" enabled="true" />
                                <check name="MISRAC2012-Rule-17.7" enabled="true" />
                                <check name="MISRAC2012-Rule-17.8" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-18">
                                <check name="MISRAC2012-Rule-18.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-18.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-18.1_c" enabled="true" />
                                <check name="MISRAC2012-Rule-18.1_d" enabled="true" />
                                <check name="MISRAC2012-Rule-18.2" enabled="true" />
                                <check name="MISRAC2012-Rule-18.3" enabled="true" />
                                <check name="MISRAC2012-Rule-18.4" enabled="true" />
                                <check name="MISRAC2012-Rule-18.5" enabled="false" />
                                <check name="MISRAC2012-Rule-18.6_a" enabled="true" />
                                <check name="MISRAC2012-Rule-18.6_b" enabled="true" />
                                <check name="MISRAC2012-Rule-18.6_c" enabled="true" />
                                <check name="MISRAC2012-Rule-18.6_d" enabled="true" />
                                <check name="MISRAC2012-Rule-18.7" enabled="true" />
                                <check name="MISRAC2012-Rule-18.8" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-19">
                                <check name="MISRAC2012-Rule-19.1" enabled="true" />
                                <check name="MISRAC2012-Rule-19.2" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-20">
                                <check name="MISRAC2012-Rule-20.1" enabled="false" />
                                <check name="MISRAC2012-Rule-20.2" enabled="true" />
                                <check name="MISRAC2012-Rule-20.4_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-20.4_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-20.5" enabled="false" />
                                <check name="MISRAC2012-Rule-20.7" enabled="true" />
                                <check name="MISRAC2012-Rule-20.10" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-21">
                                <check name="MISRAC2012-Rule-21.1" enabled="true" />
                                <check name="MISRAC2012-Rule-21.2" enabled="true" />
                                <check name="MISRAC2012-Rule-21.3" enabled="true" />
                                <check name="MISRAC2012-Rule-21.4" enabled="true" />
                                <check name="MISRAC2012-Rule-21.5" enabled="true" />
                                <check name="MISRAC2012-Rule-21.6" enabled="true" />
                                <check name="MISRAC2012-Rule-21.7" enabled="true" />
                                <check name="MISRAC2012-Rule-21.8" enabled="true" />
                                <check name="MISRAC2012-Rule-21.9" enabled="true" />
                                <check name="MISRAC2012-Rule-21.10" enabled="true" />
                                <check name="MISRAC2012-Rule-21.11" enabled="true" />
                                <check name="MISRAC2012-Rule-21.12_a" enabled="false" />
                                <check name="MISRAC2012-Rule-21.12_b" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-22">
                                <check name="MISRAC2012-Rule-22.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-22.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-22.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-22.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-22.2_c" enabled="true" />
                                <check name="MISRAC2012-Rule-22.3" enabled="true" />
                                <check name="MISRAC2012-Rule-22.4" enabled="true" />
                                <check name="MISRAC2012-Rule-22.5_a" enabled="true" />
                                <check name="MISRAC2012-Rule-22.5_b" enabled="true" />
                                <check name="MISRAC2012-Rule-22.6" enabled="true" />
                            </group>
                        </package>
                        <package name="MISRAC++2008" enabled="false">
                            <group enabled="true" name="MISRAC++2008-0-1">
                                <check name="MISRAC++2008-0-1-1" enabled="true" />
                                <check name="MISRAC++2008-0-1-2_a" enabled="true" />
                                <check name="MISRAC++2008-0-1-2_b" enabled="true" />
                                <check name="MISRAC++2008-0-1-2_c" enabled="true" />
                                <check name="MISRAC++2008-0-1-3" enabled="true" />
                                <check name="MISRAC++2008-0-1-4_a" enabled="true" />
                                <check name="MISRAC++2008-0-1-4_b" enabled="true" />
                                <check name="MISRAC++2008-0-1-6" enabled="true" />
                                <check name="MISRAC++2008-0-1-7" enabled="true" />
                                <check name="MISRAC++2008-0-1-8" enabled="false" />
                                <check name="MISRAC++2008-0-1-9" enabled="true" />
                                <check name="MISRAC++2008-0-1-11" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-0-2">
                                <check name="MISRAC++2008-0-2-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-0-3">
                                <check name="MISRAC++2008-0-3-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-7">
                                <check name="MISRAC++2008-2-7-1" enabled="true" />
                                <check name="MISRAC++2008-2-7-2" enabled="true" />
                                <check name="MISRAC++2008-2-7-3" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-10">
                                <check name="MISRAC++2008-2-10-1" enabled="true" />
                                <check name="MISRAC++2008-2-10-2" enabled="true" />
                                <check name="MISRAC++2008-2-10-3" enabled="true" />
                                <check name="MISRAC++2008-2-10-4" enabled="true" />
                                <check name="MISRAC++2008-2-10-5" enabled="false" />
                                <check name="MISRAC++2008-2-10-6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-13">
                                <check name="MISRAC++2008-2-13-2" enabled="true" />
                                <check name="MISRAC++2008-2-13-3" enabled="true" />
                                <check name="MISRAC++2008-2-13-4_a" enabled="true" />
                                <check name="MISRAC++2008-2-13-4_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-3-1">
                                <check name="MISRAC++2008-3-1-1" enabled="true" />
                                <check name="MISRAC++2008-3-1-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-3-9">
                                <check name="MISRAC++2008-3-9-2" enabled="false" />
                                <check name="MISRAC++2008-3-9-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-4-5">
                                <check name="MISRAC++2008-4-5-1" enabled="true" />
                                <check name="MISRAC++2008-4-5-2" enabled="true" />
                                <check name="MISRAC++2008-4-5-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-0">
                                <check name="MISRAC++2008-5-0-1_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-1_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-1_c" enabled="true" />
                                <check name="MISRAC++2008-5-0-2" enabled="false" />
                                <check name="MISRAC++2008-5-0-3" enabled="true" />
                                <check name="MISRAC++2008-5-0-4" enabled="true" />
                                <check name="MISRAC++2008-5-0-5" enabled="true" />
                                <check name="MISRAC++2008-5-0-6" enabled="true" />
                                <check name="MISRAC++2008-5-0-7" enabled="true" />
                                <check name="MISRAC++2008-5-0-8" enabled="true" />
                                <check name="MISRAC++2008-5-0-9" enabled="true" />
                                <check name="MISRAC++2008-5-0-10" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_c" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_d" enabled="true" />
                                <check name="MISRAC++2008-5-0-14" enabled="true" />
                                <check name="MISRAC++2008-5-0-15_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-15_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_c" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_d" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_e" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_f" enabled="true" />
                                <check name="MISRAC++2008-5-0-19" enabled="true" />
                                <check name="MISRAC++2008-5-0-21" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-2">
                                <check name="MISRAC++2008-5-2-4" enabled="true" />
                                <check name="MISRAC++2008-5-2-5" enabled="true" />
                                <check name="MISRAC++2008-5-2-6" enabled="true" />
                                <check name="MISRAC++2008-5-2-7" enabled="true" />
                                <check name="MISRAC++2008-5-2-9" enabled="false" />
                                <check name="MISRAC++2008-5-2-10" enabled="false" />
                                <check name="MISRAC++2008-5-2-11_a" enabled="true" />
                                <check name="MISRAC++2008-5-2-11_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-3">
                                <check name="MISRAC++2008-5-3-1" enabled="true" />
                                <check name="MISRAC++2008-5-3-2_a" enabled="true" />
                                <check name="MISRAC++2008-5-3-2_b" enabled="true" />
                                <check name="MISRAC++2008-5-3-3" enabled="true" />
                                <check name="MISRAC++2008-5-3-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-8">
                                <check name="MISRAC++2008-5-8-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-14">
                                <check name="MISRAC++2008-5-14-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-18">
                                <check name="MISRAC++2008-5-18-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-19">
                                <check name="MISRAC++2008-5-19-1" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-2">
                                <check name="MISRAC++2008-6-2-1" enabled="true" />
                                <check name="MISRAC++2008-6-2-2" enabled="true" />
                                <check name="MISRAC++2008-6-2-3" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-3">
                                <check name="MISRAC++2008-6-3-1_a" enabled="true" />
                                <check name="MISRAC++2008-6-3-1_b" enabled="true" />
                                <check name="MISRAC++2008-6-3-1_c" enabled="true" />
                                <check name="MISRAC++2008-6-3-1_d" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-4">
                                <check name="MISRAC++2008-6-4-1" enabled="true" />
                                <check name="MISRAC++2008-6-4-2" enabled="true" />
                                <check name="MISRAC++2008-6-4-3" enabled="true" />
                                <check name="MISRAC++2008-6-4-4" enabled="true" />
                                <check name="MISRAC++2008-6-4-5" enabled="true" />
                                <check name="MISRAC++2008-6-4-6" enabled="true" />
                                <check name="MISRAC++2008-6-4-7" enabled="true" />
                                <check name="MISRAC++2008-6-4-8" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-5">
                                <check name="MISRAC++2008-6-5-1_a" enabled="true" />
                                <check name="MISRAC++2008-6-5-2" enabled="true" />
                                <check name="MISRAC++2008-6-5-3" enabled="true" />
                                <check name="MISRAC++2008-6-5-4" enabled="true" />
                                <check name="MISRAC++2008-6-5-6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-6">
                                <check name="MISRAC++2008-6-6-1" enabled="true" />
                                <check name="MISRAC++2008-6-6-2" enabled="true" />
                                <check name="MISRAC++2008-6-6-4" enabled="true" />
                                <check name="MISRAC++2008-6-6-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-1">
                                <check name="MISRAC++2008-7-1-1" enabled="true" />
                                <check name="MISRAC++2008-7-1-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-2">
                                <check name="MISRAC++2008-7-2-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-4">
                                <check name="MISRAC++2008-7-4-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-5">
                                <check name="MISRAC++2008-7-5-1_a" enabled="true" />
                                <check name="MISRAC++2008-7-5-1_b" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_a" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_b" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_c" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_d" enabled="true" />
                                <check name="MISRAC++2008-7-5-4_a" enabled="false" />
                                <check name="MISRAC++2008-7-5-4_b" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-0">
                                <check name="MISRAC++2008-8-0-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-4">
                                <check name="MISRAC++2008-8-4-1" enabled="true" />
                                <check name="MISRAC++2008-8-4-3" enabled="true" />
                                <check name="MISRAC++2008-8-4-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-5">
                                <check name="MISRAC++2008-8-5-1_a" enabled="true" />
                                <check name="MISRAC++2008-8-5-1_b" enabled="true" />
                                <check name="MISRAC++2008-8-5-1_c" enabled="true" />
                                <check name="MISRAC++2008-8-5-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-3">
                                <check name="MISRAC++2008-9-3-1" enabled="true" />
                                <check name="MISRAC++2008-9-3-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-5">
                                <check name="MISRAC++2008-9-5-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-6">
                                <check name="MISRAC++2008-9-6-2" enabled="true" />
                                <check name="MISRAC++2008-9-6-3" enabled="true" />
                                <check name="MISRAC++2008-9-6-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-12-1">
                                <check name="MISRAC++2008-12-1-1_a" enabled="true" />
                                <check name="MISRAC++2008-12-1-1_b" enabled="true" />
                                <check name="MISRAC++2008-12-1-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-0">
                                <check name="MISRAC++2008-15-0-2" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-1">
                                <check name="MISRAC++2008-15-1-2" enabled="true" />
                                <check name="MISRAC++2008-15-1-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-3">
                                <check name="MISRAC++2008-15-3-1" enabled="true" />
                                <check name="MISRAC++2008-15-3-2" enabled="false" />
                                <check name="MISRAC++2008-15-3-3" enabled="true" />
                                <check name="MISRAC++2008-15-3-4" enabled="true" />
                                <check name="MISRAC++2008-15-3-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-5">
                                <check name="MISRAC++2008-15-5-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-0">
                                <check name="MISRAC++2008-16-0-3" enabled="true" />
                                <check name="MISRAC++2008-16-0-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-2">
                                <check name="MISRAC++2008-16-2-2" enabled="true" />
                                <check name="MISRAC++2008-16-2-3" enabled="true" />
                                <check name="MISRAC++2008-16-2-4" enabled="true" />
                                <check name="MISRAC++2008-16-2-5" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-3">
                                <check name="MISRAC++2008-16-3-1" enabled="true" />
                                <check name="MISRAC++2008-16-3-2" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-17-0">
                                <check name="MISRAC++2008-17-0-1" enabled="true" />
                                <check name="MISRAC++2008-17-0-3" enabled="true" />
                                <check name="MISRAC++2008-17-0-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-0">
                                <check name="MISRAC++2008-18-0-1" enabled="true" />
                                <check name="MISRAC++2008-18-0-2" enabled="true" />
                                <check name="MISRAC++2008-18-0-3" enabled="true" />
                                <check name="MISRAC++2008-18-0-4" enabled="true" />
                                <check name="MISRAC++2008-18-0-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-2">
                                <check name="MISRAC++2008-18-2-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-4">
                                <check name="MISRAC++2008-18-4-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-7">
                                <check name="MISRAC++2008-18-7-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-19-3">
                                <check name="MISRAC++2008-19-3-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-27-0">
                                <check name="MISRAC++2008-27-0-1" enabled="true" />
                            </group>
                        </package>
                    </checks_tree>
                </cstat_settings>
            </data>
        </settings>
        <settings>
            <name>RuntimeChecking</name>
            <archiveVersion>0</archiveVersion>
            <data>
                <version>2</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>GenRtcDebugHeap</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcEnableBoundsChecking</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcCheckPtrsNonInstrMem</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcTrackPointerBounds</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcCheckAccesses</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcGenerateEntries</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcNrTrackedPointers</name>
                    <state>1000</state>
                </option>
                <option>
                    <name>GenRtcIntOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIncUnsigned</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIntConversion</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcInclExplicit</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIntShiftOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcInclUnsignedShiftOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcUnhandledCase</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcDivByZero</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcEnable</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcCheckPtrsNonInstrFunc</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
    </configuration>
    <group>
        <name>awtk</name>
        <group>
            <name>3rd</name>
            <group>
                <name>cjson</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\cjson\cJSON.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\cjson\cJSON.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\cjson\cJSON_Utils.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\cjson\cJSON_Utils.h</name>
                </file>
            </group>
            <group>
                <name>gpinyin</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\gpinyin\src\dictlist.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\gpinyin\src\dicttrie.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\gpinyin\src\lpicache.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\gpinyin\src\matrixsearch.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\gpinyin\src\mystdlib.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\gpinyin\src\ngram.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\gpinyin\src\pinyinime.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\gpinyin\src\searchutility.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\gpinyin\src\spellingtrie.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\gpinyin\src\splparser.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\gpinyin\src\utf16char.cpp</name>
                </file>
            </group>
            <group>
                <name>libpng</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libpng\png.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libpng\png.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libpng\pngconf.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libpng\pngdebug.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libpng\pngerror.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libpng\pngget.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libpng\pnginfo.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libpng\pnglibconf.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libpng\pngmem.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libpng\pngpread.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libpng\pngpriv.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libpng\pngread.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libpng\pngrio.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libpng\pngrtran.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libpng\pngrutil.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libpng\pngset.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libpng\pngstruct.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libpng\pngtrans.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libpng\pngwio.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libpng\pngwrite.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libpng\pngwtran.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libpng\pngwutil.c</name>
                </file>
            </group>
            <group>
                <name>libunibreak</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libunibreak\emojidef.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libunibreak\emojidef.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libunibreak\graphemebreak.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libunibreak\graphemebreak.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libunibreak\graphemebreakdef.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libunibreak\linebreak.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libunibreak\linebreak.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libunibreak\linebreakdata.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libunibreak\linebreakdef.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libunibreak\linebreakdef.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libunibreak\unibreakbase.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libunibreak\unibreakbase.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libunibreak\unibreakdef.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libunibreak\unibreakdef.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libunibreak\wordbreak.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libunibreak\wordbreak.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\libunibreak\wordbreakdef.h</name>
                </file>
            </group>
            <group>
                <name>lz4</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\lz4\lz4.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\lz4\lz4.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\lz4\lz4frame.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\lz4\lz4frame.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\lz4\lz4frame_static.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\lz4\lz4hc.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\lz4\lz4hc.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\lz4\xxhash.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\lz4\xxhash.h</name>
                </file>
            </group>
            <group>
                <name>miniz</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\miniz\miniz.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\miniz\miniz.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\miniz\miniz_common.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\miniz\miniz_export.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\miniz\miniz_tdef.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\miniz\miniz_tdef.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\miniz\miniz_tinfl.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\miniz\miniz_tinfl.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\miniz\miniz_zip.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\miniz\miniz_zip.h</name>
                </file>
            </group>
            <group>
                <name>nanovg</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\nanovg\base\fontstash.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\nanovg\base\nanovg.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\nanovg\base\nanovg.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\nanovg\base\stb_image.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\nanovg\base\stb_truetype.h</name>
                </file>
            </group>
            <group>
                <name>pixman</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\pixman\pixman\pixman.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\pixman\pixman\pixman.h</name>
                </file>
            </group>
            <group>
                <name>xm</name>
                <group>
                    <name>include</name>
                </group>
                <group>
                    <name>src</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\xm\src\main_loop_xm.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\xm\src\native_window_xm.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\xm\src\native_window_xm.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\xm\src\vgcanvas_nanovg_vg.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\xm\src\xm_hmi_host.c</name>
                    </file>
                </group>
            </group>
            <group>
                <name>zlib</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\zlib\adler32.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\zlib\compress.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\zlib\crc32.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\zlib\crc32.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\zlib\deflate.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\zlib\deflate.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\zlib\gzguts.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\zlib\infback.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\zlib\inffast.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\zlib\inffast.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\zlib\inffixed.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\zlib\inflate.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\zlib\inflate.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\zlib\inftrees.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\zlib\inftrees.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\zlib\trees.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\zlib\trees.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\zlib\uncompr.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\zlib\zconf.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\zlib\zlib.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\zlib\zutil.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\3rd\zlib\zutil.h</name>
                </file>
            </group>
        </group>
        <group>
            <name>demos</name>
            <file>
                <name>$PROJ_DIR$\..\lib\awtk\awtk\demos\assets.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\lib\awtk\awtk\demos\assets.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\lib\awtk\awtk\demos\demo1_app.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\lib\awtk\awtk\demos\demo_animator_app.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\lib\awtk\awtk\demos\demo_basic.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\lib\awtk\awtk\demos\demo_desktop.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\lib\awtk\awtk\demos\demo_thread_app.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\lib\awtk\awtk\demos\demo_ui_app.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\lib\awtk\awtk\demos\demo_vg_app.c</name>
            </file>
        </group>
        <group>
            <name>examples</name>
        </group>
        <group>
            <name>src</name>
            <group>
                <name>base</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\asset_loader.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\asset_loader.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\asset_loader_default.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\asset_loader_default.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\asset_loader_zip.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\asset_loader_zip.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\assets_manager.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\assets_manager.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\awtk_config_sample.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\bidi.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\bidi.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\bitmap.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\bitmap.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\canvas.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\canvas.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\canvas_offline.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\children_layouter.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\children_layouter.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\children_layouter_factory.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\children_layouter_factory.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\clip_board.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\clip_board.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\data_reader_asset.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\data_reader_asset.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\date_time_format.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\date_time_format.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\dialog.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\dialog.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\dialog_highlighter.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\dialog_highlighter.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\dialog_highlighter_factory.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\dialog_highlighter_factory.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\enums.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\enums.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\event_queue.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\event_queue.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\event_recorder_player.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\event_recorder_player.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\events.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\events.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\font.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\font.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\font_loader.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\font_loader.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\font_manager.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\font_manager.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\g2d.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\glyph_cache.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\glyph_cache.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\graphic_buffer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\graphic_buffer.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\hscrollable.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\hscrollable.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\idle.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\idle.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\image_base.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\image_base.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\image_loader.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\image_loader.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\image_manager.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\image_manager.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\input_device_status.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\input_device_status.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\input_engine.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\input_engine.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\input_method.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\input_method.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\keys.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\layout.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\layout.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\layout_def.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\lcd.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\lcd.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\lcd_profile.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\lcd_profile.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\line_break.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\line_break.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\locale_info.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\locale_info.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\main_loop.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\main_loop.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\native_window.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\native_window.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\pixel.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\pixel_pack_unpack.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\self_layouter.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\self_layouter.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\self_layouter_factory.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\self_layouter_factory.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\shortcut.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\shortcut.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\style.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\style.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\style_const.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\style_const.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\style_factory.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\style_factory.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\style_mutable.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\style_mutable.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\suggest_words.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\suggest_words.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\system_info.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\system_info.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\text_edit.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\text_edit.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\theme.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\theme.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\timer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\timer.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\types_def.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\ui_builder.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\ui_builder.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\ui_feedback.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\ui_feedback.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\ui_loader.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\ui_loader.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\velocity.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\velocity.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\vgcanvas.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\vgcanvas.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\widget.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\widget.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\widget_animator.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\widget_animator.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\widget_animator_factory.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\widget_animator_factory_null.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\widget_animator_manager.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\widget_animator_manager.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\widget_consts.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\widget_factory.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\widget_factory.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\widget_vtable.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\widget_vtable.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\window.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\window.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\window_animator.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\window_animator.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\window_animator_factory.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\window_animator_factory.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\window_base.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\window_base.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\window_manager.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\base\window_manager.h</name>
                </file>
            </group>
            <group>
                <name>blend</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgr565_bgr565.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgr565_bgr565.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgr565_bgra8888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgr565_bgra8888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgr565_rgb565.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgr565_rgb565.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgr565_rgba8888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgr565_rgba8888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgr888_bgr565.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgr888_bgr565.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgr888_bgr888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgr888_bgr888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgr888_bgra8888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgr888_bgra8888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgr888_rgb565.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgr888_rgb565.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgr888_rgba8888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgr888_rgba8888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgra8888_bgr565.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgra8888_bgr565.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgra8888_bgra8888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgra8888_bgra8888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgra8888_rgb565.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgra8888_rgb565.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgra8888_rgba8888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_bgra8888_rgba8888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgb565_bgr565.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgb565_bgr565.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgb565_bgra8888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgb565_bgra8888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgb565_rgb565.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgb565_rgb565.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgb565_rgba8888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgb565_rgba8888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgb888_bgr565.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgb888_bgr565.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgb888_bgra8888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgb888_bgra8888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgb888_rgb565.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgb888_rgb565.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgb888_rgb888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgb888_rgb888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgb888_rgba8888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgb888_rgba8888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgba8888_bgr565.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgba8888_bgr565.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgba8888_bgra8888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgba8888_bgra8888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgba8888_rgb565.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgba8888_rgb565.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgba8888_rgba8888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\blend_image_rgba8888_rgba8888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\fill_image_abgr8888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\fill_image_abgr8888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\fill_image_argb8888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\fill_image_argb8888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\fill_image_bgr565.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\fill_image_bgr565.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\fill_image_bgr888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\fill_image_bgr888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\fill_image_bgra8888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\fill_image_bgra8888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\fill_image_rgb565.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\fill_image_rgb565.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\fill_image_rgb888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\fill_image_rgb888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\fill_image_rgba8888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\fill_image_rgba8888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\gen.sh</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\image_g2d.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\image_g2d.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\rotate_image_bgr565.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\rotate_image_bgr565.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\rotate_image_bgr888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\rotate_image_bgr888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\rotate_image_bgra8888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\rotate_image_bgra8888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\rotate_image_rgb565.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\rotate_image_rgb565.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\rotate_image_rgb888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\rotate_image_rgb888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\rotate_image_rgba8888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\rotate_image_rgba8888.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\soft_g2d.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\soft_g2d.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\blend\stm32_g2d.c</name>
                </file>
            </group>
            <group>
                <name>charset</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\charset\encoding.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\charset\encoding.h</name>
                </file>
            </group>
            <group>
                <name>clip_board</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\clip_board\clip_board_default.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\clip_board\clip_board_default.h</name>
                </file>
            </group>
            <group>
                <name>compressors</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\compressors\compressor_miniz.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\compressors\compressor_miniz.h</name>
                </file>
            </group>
            <group>
                <name>conf_io</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\conf_io\app_conf.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\conf_io\app_conf.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\conf_io\app_conf_init.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\conf_io\app_conf_init.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\conf_io\app_conf_init_ini.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\conf_io\app_conf_init_ini.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\conf_io\app_conf_init_json.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\conf_io\app_conf_init_json.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\conf_io\app_conf_init_ubjson.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\conf_io\app_conf_init_ubjson.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\conf_io\conf_ini.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\conf_io\conf_ini.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\conf_io\conf_json.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\conf_io\conf_json.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\conf_io\conf_node.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\conf_io\conf_node.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\conf_io\conf_obj.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\conf_io\conf_obj.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\conf_io\conf_ubjson.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\conf_io\conf_ubjson.h</name>
                </file>
            </group>
            <group>
                <name>dialog_highlighters</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\dialog_highlighters\dialog_highlighter_builtins.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\dialog_highlighters\dialog_highlighter_builtins.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\dialog_highlighters\dialog_highlighter_default.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\dialog_highlighters\dialog_highlighter_default.h</name>
                </file>
            </group>
            <group>
                <name>ext_widgets</name>
                <group>
                    <name>awtk-widget-chart-view</name>
                    <group>
                        <name>src</name>
                        <group>
                            <name>base</name>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\base\series_data.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\base\series_fifo.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\base\series_fifo.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\base\series_fifo_default.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\base\series_fifo_default.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\base\series_fifo_event.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\base\series_fifo_event.h</name>
                            </file>
                        </group>
                        <group>
                            <name>chart-view</name>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\axis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\axis.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\axis_p.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\axis_p.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\axis_types.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\bar_series.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\bar_series.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\bar_series_minmax.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\bar_series_minmax.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\chart_animator.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\chart_animator.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\chart_utils.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\chart_utils.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\chart_view.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\chart_view.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\line_series.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\line_series.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\line_series_colorful.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\line_series_colorful.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\series.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\series.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\series_p.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\series_p.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\series_types.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\tooltip.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\tooltip.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\tooltip_types.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\x_axis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\x_axis.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\y_axis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view\y_axis.h</name>
                            </file>
                        </group>
                        <group>
                            <name>pie-slic</name>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\pie_slice\pie_slice.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\pie_slice\pie_slice.h</name>
                            </file>
                        </group>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view_register.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-chart-view\src\chart_view_register.h</name>
                        </file>
                    </group>
                </group>
                <group>
                    <name>awtk-widget-qr</name>
                    <group>
                        <name>qr</name>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr\bitstream.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr\bitstream.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr\config.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr\mask.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr\mask.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr\mmask.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr\mmask.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr\mqrspec.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr\mqrspec.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr\qr.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr\qr.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr\qrencode.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr\qrencode.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr\qrencode_inner.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr\qrinput.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr\qrinput.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr\qrspec.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr\qrspec.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr\rsecc.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr\rsecc.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr\split.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr\split.h</name>
                        </file>
                    </group>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr_register.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk-widget-qr\src\qr_register.h</name>
                    </file>
                </group>
                <group>
                    <name>canvas_widget</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\canvas_widget\canvas_widget.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\canvas_widget\canvas_widget.h</name>
                    </file>
                </group>
                <group>
                    <name>color_picker</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\color_picker\color_component.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\color_picker\color_component.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\color_picker\color_picker.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\color_picker\color_picker.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\color_picker\color_picker_const.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\color_picker\rgb_and_hsv.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\color_picker\rgb_and_hsv.h</name>
                    </file>
                </group>
                <group>
                    <name>combo_box_ex</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\combo_box_ex\combo_box_ex.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\combo_box_ex\combo_box_ex.h</name>
                    </file>
                </group>
                <group>
                    <name>features</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\features\draggable.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\features\draggable.h</name>
                    </file>
                </group>
                <group>
                    <name>file_browser</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\file_browser\file_browser.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\file_browser\file_browser.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\file_browser\file_browser_view.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\file_browser\file_browser_view.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\file_browser\file_chooser.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\file_browser\file_chooser.h</name>
                    </file>
                </group>
                <group>
                    <name>gif_image</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\gif_image\gif_image.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\gif_image\gif_image.h</name>
                    </file>
                </group>
                <group>
                    <name>guage</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\gauge\gauge.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\gauge\gauge.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\gauge\gauge_pointer.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\gauge\gauge_pointer.h</name>
                    </file>
                </group>
                <group>
                    <name>image_animation</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\image_animation\image_animation.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\image_animation\image_animation.h</name>
                    </file>
                </group>
                <group>
                    <name>image_value</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\image_value\image_value.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\image_value\image_value.h</name>
                    </file>
                </group>
                <group>
                    <name>keyboard</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\keyboard\candidates.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\keyboard\candidates.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\keyboard\keyboard.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\keyboard\keyboard.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\keyboard\lang_indicator.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\keyboard\lang_indicator.h</name>
                    </file>
                </group>
                <group>
                    <name>mledit</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\mledit\line_number.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\mledit\line_number.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\mledit\mledit.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\mledit\mledit.h</name>
                    </file>
                </group>
                <group>
                    <name>mutable_image</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\mutable_image\mutable_image.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\mutable_image\mutable_image.h</name>
                    </file>
                </group>
                <group>
                    <name>progress_circle</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\progress_circle\progress_circle.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\progress_circle\progress_circle.h</name>
                    </file>
                </group>
                <group>
                    <name>rich_text</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\rich_text\rich_text.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\rich_text\rich_text.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\rich_text\rich_text_node.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\rich_text\rich_text_node.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\rich_text\rich_text_parser.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\rich_text\rich_text_parser.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\rich_text\rich_text_render_node.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\rich_text\rich_text_render_node.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\rich_text\rich_text_view.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\rich_text\rich_text_view.h</name>
                    </file>
                </group>
                <group>
                    <name>scroll_label</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\scroll_label\hscroll_label.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\scroll_label\hscroll_label.h</name>
                    </file>
                </group>
                <group>
                    <name>scroll_view</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\scroll_view\children_layouter_list_view.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\scroll_view\children_layouter_list_view.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\scroll_view\list_item.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\scroll_view\list_item.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\scroll_view\list_view.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\scroll_view\list_view.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\scroll_view\list_view_h.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\scroll_view\list_view_h.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\scroll_view\scroll_bar.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\scroll_view\scroll_bar.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\scroll_view\scroll_view.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\scroll_view\scroll_view.h</name>
                    </file>
                </group>
                <group>
                    <name>slide_menu</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\slide_menu\slide_menu.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\slide_menu\slide_menu.h</name>
                    </file>
                </group>
                <group>
                    <name>slide_view</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\slide_view\slide_indicator.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\slide_view\slide_indicator.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\slide_view\slide_view.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\slide_view\slide_view.h</name>
                    </file>
                </group>
                <group>
                    <name>svg_image</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\svg_image\svg_image.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\svg_image\svg_image.h</name>
                    </file>
                </group>
                <group>
                    <name>switch</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\switch\switch.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\switch\switch.h</name>
                    </file>
                </group>
                <group>
                    <name>text_selector</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\text_selector\text_selector.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\text_selector\text_selector.h</name>
                    </file>
                </group>
                <group>
                    <name>time_clock</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\time_clock\time_clock.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\time_clock\time_clock.h</name>
                    </file>
                </group>
                <group>
                    <name>vpage</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\vpage\vpage.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\vpage\vpage.h</name>
                    </file>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\ext_widgets.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ext_widgets\ext_widgets.h</name>
                </file>
            </group>
            <group>
                <name>font_loader</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\font_loader\font_loader_bitmap.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\font_loader\font_loader_bitmap.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\font_loader\font_loader_ft.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\font_loader\font_loader_ft.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\font_loader\font_loader_stb.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\font_loader\font_loader_stb.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\font_loader\font_loader_truetype.h</name>
                </file>
            </group>
            <group>
                <name>fscript_ext</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_app_conf.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_app_conf.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_array.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_array.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_bits.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_bits.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_crc.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_crc.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_date_time.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_date_time.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_endian.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_endian.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_ext.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_ext.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_fs.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_fs.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_iostream.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_iostream.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_iostream_file.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_iostream_file.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_iostream_inet.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_iostream_inet.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_iostream_serial.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_iostream_serial.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_istream.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_istream.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_json.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_json.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_math.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_math.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_object.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_object.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_ostream.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_ostream.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_rbuffer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_rbuffer.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_typed_array.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_typed_array.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_utils.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_utils.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_wbuffer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_wbuffer.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_widget.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\fscript_ext\fscript_widget.h</name>
                </file>
            </group>
            <group>
                <name>graphic_buffer</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\graphic_buffer\graphic_buffer_default.c</name>
                </file>
            </group>
            <group>
                <name>image_loader</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\image_loader\image_loader_libpng.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\image_loader\image_loader_libpng.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\image_loader\image_loader_stb.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\image_loader\image_loader_stb.h</name>
                </file>
            </group>
            <group>
                <name>input_engines</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\input_engines\ime_utils.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\input_engines\ime_utils.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\input_engines\input_engine_null.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\input_engines\input_engine_null.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\input_engines\input_engine_pinyin.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\input_engines\input_engine_pinyin.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\input_engines\input_engine_spinyin.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\input_engines\input_engine_t9.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\input_engines\input_engine_t9ext.c</name>
                </file>
            </group>
            <group>
                <name>input_methods</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\input_methods\input_method_creator.c</name>
                </file>
            </group>
            <group>
                <name>layouters</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\layouters\children_layouter_builtins.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\layouters\children_layouter_builtins.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\layouters\children_layouter_default.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\layouters\children_layouter_default.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\layouters\children_layouter_parser.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\layouters\self_layouter_builtins.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\layouters\self_layouter_builtins.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\layouters\self_layouter_default.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\layouters\self_layouter_default.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\layouters\self_layouter_menu.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\layouters\self_layouter_menu.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\layouters\self_layouter_parser.c</name>
                </file>
            </group>
            <group>
                <name>lcd</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\lcd\lcd_mem_bgr565.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\lcd\lcd_mem_bgra8888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\lcd\lcd_mem_rgb565.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\lcd\lcd_mem_rgba8888.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\lcd\lcd_mono.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\lcd\lcd_mono.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\lcd\lcd_nanovg.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\lcd\lcd_nanovg.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\lcd\lcd_vgcanvas.inc</name>
                </file>
            </group>
            <group>
                <name>main_loop</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\main_loop\main_loop_simple.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\main_loop\main_loop_simple.h</name>
                </file>
            </group>
            <group>
                <name>misc</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\misc\new.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\misc\new.hpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\misc\test_cpp.cpp</name>
                </file>
            </group>
            <group>
                <name>native_window</name>
            </group>
            <group>
                <name>platforms</name>
                <group>
                    <name>ark</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\platforms\ark\fs_os.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\platforms\ark\platform.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\platforms\ark\thread_with_pthread.c</name>
                    </file>
                </group>
            </group>
            <group>
                <name>streams</name>
                <group>
                    <name>buffered</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\streams\buffered\istream_buffered.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\streams\buffered\istream_buffered.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\streams\buffered\ostream_buffered.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\streams\buffered\ostream_buffered.h</name>
                    </file>
                </group>
                <group>
                    <name>file</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\streams\file\istream_file.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\streams\file\istream_file.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\streams\file\ostream_file.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\streams\file\ostream_file.h</name>
                    </file>
                </group>
                <group>
                    <name>mem</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\streams\mem\iostream_mem.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\streams\mem\iostream_mem.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\streams\mem\istream_mem.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\streams\mem\istream_mem.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\streams\mem\ostream_mem.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\streams\mem\ostream_mem.h</name>
                    </file>
                </group>
                <group>
                    <name>misc</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\streams\misc\ostream_retry.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\streams\misc\ostream_retry.h</name>
                    </file>
                </group>
                <group>
                    <name>noisy</name>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\streams\noisy\iostream_noisy.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\streams\noisy\iostream_noisy.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\streams\noisy\ostream_noisy.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\lib\awtk\awtk\src\streams\noisy\ostream_noisy.h</name>
                    </file>
                </group>
            </group>
            <group>
                <name>svg</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\svg\bsvg.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\svg\bsvg.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\svg\bsvg_builder.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\svg\bsvg_builder.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\svg\bsvg_common.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\svg\bsvg_draw.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\svg\bsvg_draw.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\svg\bsvg_to_svg.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\svg\bsvg_to_svg.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\svg\svg_path.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\svg\svg_path.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\svg\svg_path_parser.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\svg\svg_path_parser.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\svg\svg_shape.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\svg\svg_shape.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\svg\svg_to_bsvg.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\svg\svg_to_bsvg.h</name>
                </file>
            </group>
            <group>
                <name>tkc</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\action_queue.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\action_queue.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\action_thread.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\action_thread.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\action_thread_pool.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\action_thread_pool.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\asset_info.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\asset_info.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\async.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\async.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\buffer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\buffer.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\color.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\color.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\color_parser.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\color_parser.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\compressor.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\compressor.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\cond.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\cond_var.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\cond_var.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\crc.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\crc.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\darray.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\darray.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\data_reader.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\data_reader.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\data_reader_factory.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\data_reader_factory.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\data_reader_file.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\data_reader_file.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\data_reader_mem.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\data_reader_mem.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\data_writer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\data_writer.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\data_writer_factory.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\data_writer_factory.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\data_writer_file.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\data_writer_file.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\data_writer_wbuffer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\data_writer_wbuffer.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\date_time.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\date_time.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\dl.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\easing.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\easing.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\emitter.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\emitter.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\endian.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\event.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\event.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\event_source.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\event_source.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\event_source_fd.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\event_source_fd.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\event_source_idle.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\event_source_idle.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\event_source_manager.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\event_source_manager.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\event_source_manager_default.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\event_source_manager_default.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\event_source_timer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\event_source_timer.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\fs.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\fs.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\fscript.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\fscript.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\func_call_parser.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\func_call_parser.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\func_desc.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\idle_info.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\idle_info.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\idle_manager.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\idle_manager.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\int_str.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\int_str.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\iostream.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\iostream.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\istream.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\istream.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\line_parser.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\log.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\log.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\matrix.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\matrix.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\mem.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\mem.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\mem_allocator.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\mem_allocator_debug.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\mem_allocator_lock.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\mem_allocator_oom.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\mem_allocator_pool.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\mem_allocator_simple.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\mem_allocator_std.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\mem_pool.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\mime_types.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\mmap.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\mutex.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\mutex_nest.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\mutex_nest.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\named_value.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\named_value.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\object.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\object.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\object_array.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\object_array.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\object_compositor.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\object_compositor.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\object_date_time.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\object_date_time.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\object_default.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\object_default.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\object_locker.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\object_locker.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\object_rbuffer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\object_rbuffer.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\object_typed_array.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\object_typed_array.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\object_wbuffer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\object_wbuffer.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\ostream.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\ostream.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\path.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\path.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\platform.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\plugin_manager.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\plugin_manager.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\qaction.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\qaction.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\rect.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\rect.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\ring_buffer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\ring_buffer.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\rlog.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\rlog.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\rom_fs.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\rom_fs.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\semaphore.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\slist.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\slist.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\socket_helper.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\socket_helper.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\socket_pair.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\socket_pair.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\str.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\str.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\str_str.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\str_str.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\stream_const.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\tck_utils.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\thread.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\time_now.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\time_now.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\timer_info.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\timer_info.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\timer_manager.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\timer_manager.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\tokenizer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\tokenizer.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\typed_array.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\typed_array.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\types_def.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\url.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\url.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\utf8.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\utf8.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\utils.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\value.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\value.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\value_desc.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\value_desc.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\vssver.scc</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\waitable_action_queue.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\waitable_action_queue.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\waitable_ring_buffer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\waitable_ring_buffer.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\wstr.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\tkc\wstr.h</name>
                </file>
            </group>
            <group>
                <name>ubjson</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ubjson\ubjson_const.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ubjson\ubjson_parser.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ubjson\ubjson_parser.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ubjson\ubjson_reader.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ubjson\ubjson_reader.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ubjson\ubjson_writer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ubjson\ubjson_writer.h</name>
                </file>
            </group>
            <group>
                <name>ui_loader</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ui_loader\ui_binary_writer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ui_loader\ui_binary_writer.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ui_loader\ui_builder_default.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ui_loader\ui_builder_default.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ui_loader\ui_loader_default.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ui_loader\ui_loader_default.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ui_loader\ui_loader_xml.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ui_loader\ui_loader_xml.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ui_loader\ui_serializer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ui_loader\ui_serializer.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ui_loader\ui_xml_writer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ui_loader\ui_xml_writer.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\ui_loader\window_open.c</name>
                </file>
            </group>
            <group>
                <name>vgcanvas</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\vgcanvas\vgcanvas_nanovg.inc</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\vgcanvas\vgcanvas_null.c</name>
                </file>
            </group>
            <group>
                <name>widget_animators</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widget_animators\widget_animator_factory.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widget_animators\widget_animator_move.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widget_animators\widget_animator_opacity.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widget_animators\widget_animator_prop.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widget_animators\widget_animator_prop.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widget_animators\widget_animator_prop2.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widget_animators\widget_animator_prop2.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widget_animators\widget_animator_rotation.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widget_animators\widget_animator_scale.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widget_animators\widget_animator_scroll.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widget_animators\widget_animator_scroll.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widget_animators\widget_animator_value.h</name>
                </file>
            </group>
            <group>
                <name>widgets</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\app_bar.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\app_bar.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\button.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\button.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\button_group.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\button_group.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\calibration_win.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\calibration_win.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\check_button.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\check_button.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\clip_view.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\clip_view.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\color_tile.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\color_tile.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\column.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\column.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\combo_box.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\combo_box.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\combo_box_item.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\combo_box_item.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\dialog_client.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\dialog_client.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\dialog_helper.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\dialog_title.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\dialog_title.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\digit_clock.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\digit_clock.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\dragger.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\dragger.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\edit.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\edit.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\edit_date.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\edit_ipv4.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\edit_pattern.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\edit_time.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\edit_time_full.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\grid.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\grid.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\grid_item.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\grid_item.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\group_box.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\group_box.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\image.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\image.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\label.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\label.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\overlay.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\overlay.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\pages.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\pages.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\popup.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\popup.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\progress_bar.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\progress_bar.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\row.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\row.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\slider.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\slider.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\spin_box.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\spin_box.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\system_bar.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\system_bar.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\tab_button.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\tab_button.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\tab_button_group.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\tab_button_group.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\tab_control.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\tab_control.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\view.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\view.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\vssver.scc</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\widgets.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\widgets\widgets.h</name>
                </file>
            </group>
            <group>
                <name>window_animators</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_builtins.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_builtins.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_center_scale.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_center_scale.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_common.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_common.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_fade.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_fade.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_htranslate.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_htranslate.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_popdown.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_popdown.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_popup.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_popup.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_slide.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_slide.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_slide_down.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_slide_down.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_slide_left.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_slide_left.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_slide_right.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_slide_right.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_slide_up.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_slide_up.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_vtranslate.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_animators\window_animator_vtranslate.h</name>
                </file>
            </group>
            <group>
                <name>window_manager</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_manager\window_manager_default.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\window_manager\window_manager_default.h</name>
                </file>
            </group>
            <group>
                <name>xml</name>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\xml\xml_builder.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\xml\xml_builder.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\xml\xml_parser.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\lib\awtk\awtk\src\xml\xml_parser.h</name>
                </file>
            </group>
            <file>
                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk_base.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk_ext_widgets.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk_global.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk_global.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk_tkc.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\lib\awtk\awtk\src\awtk_widgets.h</name>
            </file>
        </group>
    </group>
</project>
