#include "dock_music_ex_view.h"

#include <stdlib.h>
#include <string.h>
#include <stdio.h>

#if 0
unsigned char rawData[983] = {
	0x89, 0x50, 0x4E, 0x47, 0x0D, 0x0A, 0x1A, 0x0A, 0x00, 0x00, 0x00, 0x0D,
	0x49, 0x48, 0x44, 0x52, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00, 0x28,
	0x08, 0x06, 0x00, 0x00, 0x00, 0x8C, 0xFE, 0xB8, 0x6D, 0x00, 0x00, 0x00,
	0x01, 0x73, 0x52, 0x47, 0x42, 0x00, 0xAE, 0xCE, 0x1C, 0xE9, 0x00, 0x00,
	0x00, 0x04, 0x73, 0x42, 0x49, 0x54, 0x08, 0x08, 0x08, 0x08, 0x7C, 0x08,
	0x64, 0x88, 0x00, 0x00, 0x03, 0x81, 0x49, 0x44, 0x41, 0x54, 0x58, 0x85,
	0xED, 0x97, 0x4B, 0x68, 0x55, 0x57, 0x14, 0x86, 0xBF, 0xEB, 0x23, 0x3E,
	0xAA, 0x52, 0x51, 0x63, 0x6C, 0xAD, 0x82, 0xC5, 0x77, 0x34, 0x5A, 0xF1,
	0xD1, 0x8E, 0xB4, 0x4D, 0xE8, 0x40, 0x74, 0x50, 0xA8, 0xE0, 0x44, 0x87,
	0xE2, 0xC4, 0x81, 0xE8, 0xC0, 0xA1, 0x28, 0x68, 0x7D, 0x81, 0x18, 0xC5,
	0x3A, 0xD1, 0x81, 0x28, 0x54, 0x0B, 0x26, 0x2A, 0x5A, 0x11, 0xC1, 0x07,
	0x16, 0xF1, 0x55, 0x7C, 0x53, 0x27, 0x8A, 0xAF, 0xA8, 0x88, 0xF1, 0x15,
	0xD4, 0x18, 0xFF, 0x0E, 0xBA, 0x36, 0x59, 0xF7, 0x70, 0x72, 0xCE, 0xBE,
	0x44, 0x67, 0x77, 0xC1, 0xE5, 0x24, 0xFF, 0x59, 0xFF, 0xFA, 0xFF, 0xB3,
	0xCF, 0x3E, 0x7B, 0xAF, 0x0D, 0xE5, 0x28, 0x47, 0x39, 0xCA, 0xF1, 0x59,
	0xA3, 0xD0, 0x19, 0xB2, 0x60, 0x02, 0x30, 0x07, 0xA8, 0x03, 0x86, 0x02,
	0x55, 0x76, 0xAB, 0x09, 0xB8, 0x0F, 0x1C, 0x03, 0x1A, 0x0B, 0x70, 0xFD,
	0xD3, 0xD8, 0x2D, 0x16, 0x9F, 0x2C, 0x58, 0x27, 0x18, 0x98, 0x72, 0x6F,
	0x9A, 0xE0, 0x94, 0x40, 0xF6, 0x7B, 0x22, 0x68, 0x14, 0xEC, 0xB4, 0xDF,
	0x41, 0xC3, 0xC2, 0xFD, 0xE3, 0x82, 0x49, 0x29, 0x75, 0x06, 0x9A, 0xC6,
	0xE4, 0x52, 0xCD, 0x0D, 0x13, 0x3C, 0xB6, 0xE2, 0x73, 0x1C, 0xDE, 0x43,
	0xB0, 0xD5, 0xF0, 0x17, 0x82, 0xB5, 0x82, 0xF1, 0x19, 0x75, 0xAA, 0x05,
	0xEB, 0x05, 0xAF, 0x04, 0x6D, 0x82, 0x0D, 0x82, 0x6E, 0xEE, 0xFE, 0x5C,
	0xAB, 0xF5, 0x58, 0x30, 0x2C, 0xD6, 0x5C, 0x6F, 0xC1, 0x65, 0x23, 0x9E,
	0x14, 0x54, 0x18, 0xDE, 0xCF, 0x8D, 0xDA, 0xEF, 0x82, 0x01, 0x25, 0x3C,
	0xF0, 0x20, 0x1B, 0x59, 0x09, 0x8E, 0x0A, 0x7A, 0x19, 0x5E, 0x61, 0x1A,
	0x32, 0xCD, 0x2F, 0x62, 0x8A, 0xFD, 0x66, 0x84, 0x3B, 0x82, 0x41, 0xCE,
	0xF4, 0x59, 0xC1, 0x3B, 0xC1, 0xE2, 0x58, 0x63, 0x29, 0xB5, 0x97, 0x0A,
	0x3E, 0x08, 0x8E, 0x09, 0xBA, 0x1B, 0x56, 0x29, 0xB8, 0x6B, 0x9A, 0x6B,
	0xF3, 0x0A, 0x0C, 0x11, 0xBC, 0xB1, 0xE4, 0x1F, 0x1D, 0xBE, 0xCB, 0xB0,
	0x05, 0x19, 0xDC, 0x5F, 0xDD, 0x9C, 0xFB, 0x25, 0x23, 0x6F, 0x89, 0xE5,
	0x6C, 0x74, 0x58, 0x9D, 0x61, 0x6F, 0xD4, 0xFE, 0xA1, 0xA5, 0x92, 0xC3,
	0xFC, 0x6A, 0x70, 0xD8, 0x4C, 0xC3, 0x76, 0xE4, 0x3C, 0xDC, 0x6C, 0x67,
	0xB0, 0x2E, 0x27, 0xF7, 0x4F, 0x1B, 0xC9, 0x89, 0x0E, 0x3B, 0x68, 0xDC,
	0x2D, 0x1D, 0x91, 0x2A, 0x04, 0x2F, 0x05, 0x1F, 0x05, 0xA3, 0x1C, 0x7E,
	0x4E, 0xF0, 0x48, 0xD0, 0x27, 0x47, 0x74, 0x96, 0x33, 0x38, 0x23, 0x27,
	0xB7, 0x52, 0xF0, 0x5A, 0x70, 0xC0, 0x61, 0x63, 0x4C, 0xFB, 0x45, 0x98,
	0xF7, 0x49, 0xD2, 0xCF, 0x56, 0xFC, 0xBC, 0xC3, 0x7E, 0x30, 0x6C, 0x45,
	0x96, 0xA0, 0xE5, 0x4E, 0x77, 0x06, 0xC7, 0x45, 0xE4, 0x6F, 0x36, 0x43,
	0x23, 0x1C, 0x76, 0x21, 0xF9, 0x06, 0xBA, 0x38, 0x4E, 0x58, 0x4E, 0x1A,
	0x1C, 0x36, 0xDF, 0xAE, 0x7B, 0xF2, 0x04, 0x81, 0x16, 0xF7, 0xF7, 0xAB,
	0x88, 0xFC, 0xBD, 0xB6, 0x51, 0xCC, 0x73, 0x58, 0x63, 0xC2, 0x4B, 0x7B,
	0x08, 0xFE, 0x36, 0xF7, 0xD3, 0x1C, 0xF6, 0x8F, 0xE0, 0x76, 0x84, 0x18,
	0x82, 0x6F, 0xDD, 0x08, 0x7E, 0x19, 0x91, 0xDF, 0xD5, 0xD6, 0xC7, 0x43,
	0x0E, 0xFB, 0xDE, 0xF8, 0x67, 0x02, 0xE6, 0x47, 0x70, 0xB0, 0x5D, 0x1F,
	0x38, 0x6C, 0x0C, 0x70, 0x35, 0xC6, 0xA0, 0x1B, 0x41, 0xC5, 0x8C, 0x60,
	0x01, 0xDA, 0x80, 0x1B, 0xA6, 0x11, 0x22, 0x68, 0x07, 0x2F, 0x45, 0x06,
	0xC3, 0xE7, 0xFD, 0xCC, 0x61, 0x3D, 0x80, 0xE6, 0x12, 0x0D, 0xB6, 0x98,
	0x78, 0x4C, 0xDC, 0x03, 0x86, 0xB8, 0xFF, 0x83, 0x76, 0x65, 0x9A, 0xC1,
	0xB6, 0x14, 0xEC, 0xBD, 0x99, 0x2C, 0xC5, 0x60, 0xCC, 0xFC, 0xF3, 0xF5,
	0xBB, 0xB9, 0xFF, 0x83, 0x76, 0x21, 0x09, 0x00, 0x3C, 0xB2, 0xEB, 0xD7,
	0x0E, 0x7B, 0xEE, 0x9F, 0x26, 0x2B, 0x0A, 0xD0, 0x0A, 0x7C, 0x00, 0x5E,
	0x96, 0x60, 0xB0, 0x2A, 0xF1, 0xC6, 0xBE, 0x4A, 0x78, 0x49, 0x35, 0x38,
	0xDC, 0x61, 0xB7, 0x80, 0xEA, 0x12, 0x04, 0x5B, 0x4A, 0x1C, 0xC1, 0x6A,
	0x9B, 0x87, 0x21, 0x82, 0x76, 0xAA, 0xC1, 0x4B, 0x76, 0xFD, 0xC9, 0x61,
	0xA7, 0x81, 0x2A, 0xC1, 0xD8, 0x48, 0xC1, 0xD5, 0xC0, 0xD6, 0x98, 0x44,
	0x41, 0x0D, 0xFF, 0xEF, 0xF5, 0x27, 0x1D, 0x5C, 0x9B, 0xF0, 0x52, 0x44,
	0xA8, 0x0D, 0x5D, 0x85, 0xC3, 0x26, 0x18, 0xB6, 0x32, 0x52, 0x74, 0xB8,
	0x8A, 0xDF, 0x40, 0x56, 0xEE, 0xBA, 0x94, 0x5D, 0xEB, 0x4A, 0xB2, 0x0F,
	0xF0, 0x04, 0xBF, 0xD5, 0x8D, 0x74, 0xF8, 0x71, 0xC1, 0x53, 0x41, 0xBF,
	0x1C, 0xC1, 0xE9, 0xD6, 0xED, 0xBC, 0xF5, 0x6B, 0x69, 0x07, 0xB9, 0x03,
	0x04, 0xCD, 0x89, 0x35, 0x70, 0xB4, 0x99, 0x6B, 0x56, 0xF1, 0x87, 0x53,
	0x44, 0x0C, 0xCD, 0xC2, 0x1F, 0x0E, 0x9B, 0x61, 0xA6, 0x77, 0xE6, 0x88,
	0x2E, 0x73, 0x0B, 0xF5, 0xD2, 0x9C, 0xDC, 0xFD, 0xD6, 0x2C, 0xD4, 0x38,
	0x6C, 0x9F, 0x71, 0xEB, 0xB3, 0x88, 0x55, 0xD6, 0xF2, 0x7C, 0x14, 0x4C,
	0x71, 0xF8, 0x76, 0x23, 0x2F, 0xCC, 0xE0, 0x0E, 0x15, 0xDC, 0x12, 0xDC,
	0x54, 0xF1, 0x4A, 0x90, 0xCC, 0x4B, 0x6B, 0xB7, 0xA6, 0x9A, 0xE6, 0x6B,
	0xB9, 0x45, 0xBA, 0xA3, 0x02, 0xAB, 0xAC, 0xC0, 0xB5, 0xB0, 0x65, 0x09,
	0x7A, 0x0A, 0x4E, 0xDB, 0x2B, 0x5C, 0x94, 0x59, 0x20, 0xBB, 0xF6, 0x72,
	0x1B, 0xB9, 0x23, 0xAE, 0x61, 0xED, 0x2F, 0xB8, 0x61, 0x9A, 0xAB, 0x63,
	0x8A, 0xF4, 0x12, 0x5C, 0x34, 0xC2, 0x09, 0xD7, 0xF2, 0xF7, 0x75, 0xED,
	0xF9, 0x36, 0x41, 0xFF, 0x12, 0x8C, 0x0D, 0x16, 0xEC, 0x36, 0xEE, 0x61,
	0x41, 0x4F, 0xDA, 0xCF, 0x38, 0xA1, 0xE6, 0xC5, 0x80, 0xC7, 0x14, 0xCC,
	0x3A, 0x34, 0xD5, 0xBB, 0xC9, 0xBC, 0x4A, 0xC5, 0x7B, 0x69, 0xB2, 0x4E,
	0x8D, 0x60, 0x93, 0xBD, 0xBA, 0x56, 0xC1, 0x9A, 0x0E, 0x0E, 0x4D, 0x4D,
	0x82, 0x6F, 0x62, 0x1F, 0x38, 0x90, 0xBF, 0xCB, 0x39, 0x76, 0x9E, 0x71,
	0x1F, 0x45, 0x93, 0xE0, 0x80, 0x3B, 0x76, 0x1E, 0x16, 0x3C, 0x73, 0xF7,
	0x8F, 0x28, 0x65, 0xC1, 0x8F, 0x39, 0x76, 0x76, 0xF6, 0xE0, 0x5E, 0x63,
	0xBD, 0x5B, 0xAD, 0x3B, 0xB8, 0x0B, 0x78, 0x68, 0x8D, 0xC0, 0x5F, 0x40,
	0x43, 0x01, 0xFE, 0xED, 0x8C, 0x4E, 0x39, 0xCA, 0x51, 0x8E, 0x72, 0x7C,
	0xC6, 0xF8, 0x0F, 0x88, 0x11, 0x16, 0x49, 0x99, 0xF6, 0xC7, 0x84, 0x00,
	0x00, 0x00, 0x00, 0x49, 0x45, 0x4E, 0x44, 0xAE, 0x42, 0x60, 0x82
};
#endif

const char* home_dock_music_ex_widget_name[MUSIC_DOCK_NUM_MAX] = {
    "music_image_ex" , "music_title_ex" , "music_lyric_ex" , "music_bar" , 
    "music_prev", "music_state" , "music_next" ,"total_time" ,"curr_time" 
} ;

static widget_t* home_dock_music_ex_widget[MUSIC_DOCK_NUM_MAX] = { NULL };

typedef enum {
    MUSIC_STOP ,        //暂停
    MUSIC_PLAY ,        //播放

    MUSIC_NONE ,
}music_play_e ;

typedef enum {
    MUSIC_NORMAL     ,
    MUSIC_SELECTED   ,

    MUSIC_STETE_NONE ,
}music_state_e ;   

static music_play_e is_playing = MUSIC_STOP ;
static music_state_e state     = MUSIC_NORMAL ;

const char* music_play_state_image_str[MUSIC_STETE_NONE][MUSIC_NONE] = {
    "icon_play_n"  , "icon_pause_n"  ,
    "icon_play_p"  , "icon_pause_p"  ,
};


ret_t home_dock_music_ex_view_init(widget_t* parent)
{

    if(parent == NULL) return RET_FAIL;

    for (size_t i = 0; i < MUSIC_DOCK_NUM_MAX; i++){
        home_dock_music_ex_widget[i] = widget_lookup(parent, home_dock_music_ex_widget_name[i], TRUE);
    }

    return RET_OK ;
}

//首次进入播放页面初始化
void music_ex_view_init()
{
    music_ex_view_set_focused_item(MUSIC_FOCUSED_STATE);
    return ;
}

ret_t home_refresh_music_ex_image(char *blueMusicImg )
{
    if (home_dock_music_ex_widget[MUSIC_IMAGE_EX]){
        image_set_image(home_dock_music_ex_widget[MUSIC_IMAGE_EX] , blueMusicImg ) ;
        widget_invalidate_force(home_dock_music_ex_widget[MUSIC_IMAGE_EX], NULL  ) ;
    }
    
    return RET_OK ;

}

ret_t home_refresh_music_ex_title(char *title)
{
    if (home_dock_music_ex_widget[MUSIC_TITLE_EX]){
        widget_set_text_utf8(home_dock_music_ex_widget[MUSIC_TITLE_EX] , title) ;
    }
    
    return RET_OK ;  
}


ret_t home_refresh_music_ex_lyric(char *lyric)
{
    if (home_dock_music_ex_widget[MUSIC_LYRIC_EX]){
        widget_set_text_utf8(home_dock_music_ex_widget[MUSIC_LYRIC_EX] , lyric) ;
    }
    
    return RET_OK ;
}

ret_t home_refresh_music_bar(int value ,int max)
{
    widget_t *widget = home_dock_music_ex_widget[MUSIC_BAR] ;
    if (widget){
        progress_bar_set_max(widget , max);
        progress_bar_set_value(widget , value) ;
    }

    home_refresh_music_current_time(value);
    home_refresh_music_total_time(max);

    return RET_OK ;
}

ret_t home_refresh_music_state(bool_t isplay)
{
    value_t v ;
    is_playing = isplay ? MUSIC_PLAY : MUSIC_STOP ;

    widget_t *music_state_widget = home_dock_music_ex_widget[MUSIC_STATE] ;

    if (music_state_widget)
    {
        widget_get_prop(music_state_widget ,WIDGET_PROP_STATE_FOR_STYLE , &v) ;
        // printf("value_t = %s  " , value_str(&v)) ;
        state = (tk_str_cmp(value_str(&v) , STATE_NORMAL) == 0) ? MUSIC_NORMAL : MUSIC_SELECTED ;
        (void)state ;
        widget_set_style_str(music_state_widget ,STATE_NORMAL "." STYLE_ID_ICON ,  music_play_state_image_str[MUSIC_NORMAL][is_playing]);
        widget_set_style_str(music_state_widget ,STATE_SELECTE "." STYLE_ID_ICON , music_play_state_image_str[MUSIC_SELECTED][is_playing]);
    }
    
    return RET_OK ;
}

ret_t home_refresh_music_current_time(uint32_t total_seconds)
{
    uint32_t minutes = total_seconds / 60 ;
    uint32_t seconds = total_seconds % 60;

    char buff[64]  = { 0 };

    tk_snprintf(buff , sizeof(buff) - 1, "%02d:%02d" , minutes , seconds) ;
    if (home_dock_music_ex_widget[MUSIC_CURRENT])
        widget_set_text_utf8(home_dock_music_ex_widget[MUSIC_CURRENT] , buff);

    return RET_OK ;
}


ret_t home_refresh_music_total_time(uint32_t total_seconds)
{
    static uint32_t total = 0 ;
    if (total == total_seconds)
        return RET_FAIL;

    uint32_t minutes = total_seconds / 60 ;
    uint32_t seconds = total_seconds % 60;

    total = total_seconds ;
    char buff[64]  = { 0 };

    tk_snprintf(buff , sizeof(buff) - 1, "%02d:%02d" , minutes , seconds) ;
    if (home_dock_music_ex_widget[MUSIC_TOTAL])
        widget_set_text_utf8(home_dock_music_ex_widget[MUSIC_TOTAL] , buff);

    return RET_OK ;
}

void music_ex_view_set_focused_item(music_ex_focused_e focusedIndex)
{
    int offset = MUSIC_NEXT - MUSIC_FOCUSED_NEXT ;
    for (size_t i = 0; i < MUSIC_FOCUSED_MAX ; i++)
    {
        if (home_dock_music_ex_widget[i + offset])
        {
            if (i == focusedIndex)
                widget_set_state(home_dock_music_ex_widget[i + offset], STATE_SELECTE) ;
            else
                widget_set_state(home_dock_music_ex_widget[i + offset], STATE_NORMAL ) ;

                
            widget_invalidate_force(home_dock_music_ex_widget[i + offset] , NULL)  ;
        }
    }
    
    widget_invalidate_force(home_dock_music_ex_widget[MUSIC_BAR] ,NULL);
    return ;

    // image_set_image();
}



/***********
// 图片名默认为assets_manager_load_file加载的路径
#define IMAGE_NAME "/media/sda1/AWTK.png" 

static ret_t on_unload_button_click(void* ctx, event_t* e) 
{ 
    // 点击卸载图片按钮卸载图片缓存  
    bitmap_t bitmap = {0};  widget_t* win = WIDGET(ctx);  widget_t* image = widget_lookup(win, "image", TRUE);  
    // 卸载图片管理器缓存  
    image_manager_get_bitmap(image_manager(), IMAGE_NAME, &bitmap);  image_manager_unload_bitmap(image_manager(), &bitmap);
    // 卸载资源管理器缓存 
    assets_manager_clear_cache_ex(assets_manager(), ASSET_TYPE_IMAGE, IMAGE_NAME);  widget_invalidate(image, NULL); 
    return RET_OK;
}

static ret_t on_load_button_click(void* ctx, event_t* e) 
{ 
    // 点击加载图片按钮重新加载图片缓存  
    widget_t* win = WIDGET(ctx);  widget_t* image = widget_lookup(win, "image", TRUE);
    // 将新的图片数据添加到资源管理器缓存中  
    asset_info_t* img = assets_manager_load_file(assets_manager(), ASSET_TYPE_IMAGE, IMAGE_NAME);  assets_manager_add(assets_manager(), img);
    image_set_image(image, IMAGE_NAME);
    widget_invalidate(image, NULL);  
    return RET_OK;
}

// 假设 album_cover_data 是蓝牙接收到的图片数据
extern uint8_t album_cover_data[];
extern size_t album_cover_data_size;

void load_album_cover() {
    // 创建一个 image 控件
    widget_t *image = image_create(NULL, 0, 0, 200, 200);
    if (!image) {
        // 处理创建失败的情况
        return;
    }

    // 将图片数据添加到资源管理器
    assets_manager_add_data(assets_manager(), "album_cover", ASSET_TYPE_IMAGE, ASSET_TYPE_IMAGE_PNG, album_cover_data, album_cover_data_size);

    // 设置图片控件的图片
    image_set_image(image, "album_cover");
}
************* */

